	LXI H,0050H
	MVI C,05H
	MVI E,00H
	MOV A,E
LOOP1	MOV D,M
	ADD D
	JNC LBL1
	INR E
LBL1	INX H
	INX H
	DCR C
	JNZ LOOP1
	STA 0061H
	MOV A,E
	STA 0060H
	LXI H,0051H
	MVI C,05H
	MVI E,00H
	MOV A,E
LOOP2	MOV D,M
	ADD D
	JNC LBL2
	INR E
LBL2	INX H
	INX H
	DCR C
	JNZ LOOP2
	STA 0063H
	MOV A,E
	STA 0062H
	HLT

