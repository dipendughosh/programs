	LXI H,0050H
	SHLD 0090H
	MVI A,0AH
	MOV C,A
	ADD L
	MOV L,A
	SHLD 0092H
	LHLD 0092H
	XCHG
	LHLD 0090H
LOOP	MOV A,M
	CPI 00H
	JNZ LBL1
	MVI A,01H
	STAX D
	JMP LBL
LBL1	CPI 01H
	JNZ LBL2
	MVI A,00H
	STAX D
	JMP LBL
LBL2	STAX D
LBL	INX D
	INX H
	DCR C
	JNZ LOOP
	HLT


