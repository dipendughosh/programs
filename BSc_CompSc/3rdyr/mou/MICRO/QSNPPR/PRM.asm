	LXI H,0050H
	LXI D,0070H
	MOV C,M
LOOP	INX H
	MOV A,M
	CALL DIV
	MOV A,B
	CPI 02H
	JNZ LBL1
	MOV A,M
	STAX D
	INX D
LBL1	DCR C
	JNZ LOOP
	HLT

DIV	PUSH D
	MVI E,00H
	MOV B,M
LOOP2	MOV A,M
LOOP3	CMP B
	JC LBL
	SUB B
	JNZ LOOP3
	INR E
LBL	DCR B
	JNZ LOOP2
	MOV B,E
	POP D
	RET



