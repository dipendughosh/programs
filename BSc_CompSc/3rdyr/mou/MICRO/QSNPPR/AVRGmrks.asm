	MVI D,00H
	MVI B,0AH
	LXI H,0070H
	MVI A,00H
LOOP1	MOV E,M
	ADD E
	JNC LBL1
	INR D
LBL1	INX H
	DCR B
	JNZ LOOP1
	MVI E,00H
	STA 0092H
	MOV A,D
	STA 0090H
	LDA 0090H
	CPI 00H
	JZ LBL2
	MVI C,00H
LOOP2	LDA 0092H
	SUB B
	JC LBL3
	INR E
	STA 0092H
	JMP LBL2
LBL3	INR E
	INR C
	STA 0092H
	LDA 0090H
	SUB C
	STA 0090H
	JNZ LOOP2
LBL2	LDA 0092H
LOOP3	CMP B
	JC LBL4
	INR E
LBL4	SUB B
	JNZ LOOP3
	STA 0081H
	MOV A,E
	STA 0080H
	HLT