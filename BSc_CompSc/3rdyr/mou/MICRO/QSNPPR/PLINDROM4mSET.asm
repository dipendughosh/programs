	LXI H,0060H
	LXI D,0080H
	MVI A,0AH
	STA 0050H
LOOP2	MVI A,08H
	STA 0051H
	MOV B,M
	MOV A,M
	STA 0055H
LOOP1	LDA 0055H
	RAR
	STA 0055H
	MOV A,C
	RAL
	MOV C,A
	LDA 0051H
	DCR A
	STA 0051H
	JNZ LOOP1
	MOV A,C
	CMP B
	JNZ LBL1
	STAX D
	INX D
LBL1	INX H
	LDA 0050H
	DCR A
	STA 0050H
	JNZ LOOP2
	HLT



