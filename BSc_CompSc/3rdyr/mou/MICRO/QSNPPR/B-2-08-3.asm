	LXI H,0050H
	MVI A,0A1H
	MOV M,A
	INX H
	MVI A,08H
	MOV M,A
	INX H
	MVI A,44H
	MOV M,A
	LXI H,0050H
	LXI D,0060H
	MVI A,03H
LOOP2	STA 0070H
	MVI B,08H
	MOV A,M
	STA 0075H
LOOP1	LDA 0075H
	RAR
	STA 0075H
	MOV A,C
	RAL
	MOV C,A
	DCR B
	JNZ LOOP1
	MOV A,C
	STAX D
	INX D
	INX H
	LDA 0070H
	DCR A
	JNZ LOOP2
	HLT

