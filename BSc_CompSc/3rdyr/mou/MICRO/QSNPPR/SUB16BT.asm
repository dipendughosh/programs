	MVI E,00H
	LHLD 0050H
	MOV A,H
	STA 0060H
	MOV A,L
	STA 0061H
	LDA 0052H
	MOV B,A
LOOP 	MVI C,00H
	LDA 0060H
	CPI 00H
	JZ LBL1
	LDA 0061H
	SUB B
	JC LBL2
	INR E
	STA 0061H
	JMP LBL1
LBL2	INR C
	INR E
	STA 0061H
	LDA 0060H
	SUB C
	JNZ LOOP
LBL1	MVI D,00H
LOOP2	CMP B
	JC LBL4
	INR D
	SUB B
	JNZ LOOP2
LBL4	STA 0054H
	MOV A,E
	ADD D
	STA 0053H
	HLT



