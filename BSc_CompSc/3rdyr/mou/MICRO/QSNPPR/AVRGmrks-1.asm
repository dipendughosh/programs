	MVI D,00H
	MVI B,03H
	LXI H,0070H
	MVI A,00H
LOOP1	MOV E,M
	ADD E
	JNC LBL1
	INR D
LBL1	INX H
	DCR B
	JNZ LOOP1
	MVI B,03H
	MVI E,00H
	STA 0092H
	MOV A,D
	STA 0090H
loop2	LDA 0090H
	CPI 00H
	JZ LBL2
	MVI C,00H
	LDA 0092H
	SUB B
	sta 0092h
	JC LBL3
	INR E
	JMP loop2
LBL3	INR E
	INR C
	LDA 0090H
	SUB C
	STA 0090H
	JNZ LOOP2
LBL2	LDA 0092H
LOOP3	CMP B
	JC LBL4
	INR E
	SUB B
	JNZ LOOP3
lbl4	STA 0081H
	MOV A,E
	STA 0080H
	HLT