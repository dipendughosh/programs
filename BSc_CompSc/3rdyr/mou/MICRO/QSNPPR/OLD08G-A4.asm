	MVI A,00H
	STA 005BH
	STA 005DH
	MVI B,0AH
	LXI H,0050H
	MVI D,00H
	MVI E,00H
LOOP	MOV A,M
	RAL
	JNC LBL1
	RAR
	MOV C,A
	LDA 0061H
	ADD C
	JNC LBL2
	INR D
LBL2	STA 005BH
	JMP LBL
LBL1	RAR
	MOV C,A
	LDA 006DH
	ADD C
	JNC LBL3
	INR E
LBL3	STA 0063H
LBL	INX H
	DCR B
	JNZ LOOP
	MOV A,D
	STA 005AH
	MOV A,E
	STA 005CH
	HLT

