	LXI H,0050H
	LXI B,0060H
	LXI D,0070H
	MOV A,M
	STA 0080H
	INX H
	MVI A,00H
	STAX B
	STAX D
	INX B
	INX D
LOOP1:	MOV A,M
	RAR
	JC LBL1
	RAL
	STAX B
	INX B
	LDA 0060H
	INR A
	STA 0060H
	JMP LBL2
LBL1:	RAL
	STAX D
	INX D
	LDA 0070H
	INR A
	STA 0070H
LBL2:	INX H
	LDA 0080H
	DCR A
	STA 0080H
	JNZ LOOP1
	HLT
