	LXI H,0050H
	LXI SP,00AFH
	CALL PRIME
	MOV A,C
	ANA A
	JZ LBL
	MOV A,M
	INX H
	MOV M,A
LBL:	HLT
PRIME:	PUSH PSW
	MOV B,M
	MVI D,00H
LOOP1:	MOV A,M
	CALL DIV
	MOV A,C
	ANA A
	JZ LBL3
	INR D
LBL3:	DCR B
	JNZ LOOP1
	MVI C,00H
	MVI A,02H
	CMP D
	JC LBL4
	JNZ LBL4
	MVI C,01H
LBL4:	POP PSW
	RET
DIV:	PUSH PSW
LOOP2:	CMP B
	JC LBL1
	SUB B
	JNC LOOP2
LBL1:	MVI C,00H
	ANA A
	JNZ LBL2
	MVI C,01H
LBL2:	POP PSW
	RET
