	LHLD 0090H
	LDA 0092H
	MOV D,A
	MVI B,00H
	MVI E,00H
LOOP1:	MVI C,00H
	MOV A,H
	CPI 00H
	JZ LBL2
	MOV B,A
	ADI 01H
	MOV B,A
	JNC LBL5
	INR E
LBL5:	MOV A,L
	SUB D
	MOV L,A
	JNC LBL3
	INR C
LBL3:	MOV A,H
	SUB C
	MOV H,A
	JMP LOOP1
LBL2:	MOV A,L
	CMP D
	JC LBL4
	MOV A,B
	ADI 01H
	MOV B,A
	JNC LBL6
	INR E
LBL6:	MOV A,L
	SUB D
	MOV L,A
	JNZ LBL2
LBL4:	MOV A,L
	STA 0093H
	MOV A,B
	STA 0094H
	MOV A,E
	STA 0095H
	HLT