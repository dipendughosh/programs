	LXI H,00B0H
	LXI B,00C0H
	LXI D,00D0H
	MVI A,00H
	STAX B
	STAX D
	MOV A,M
	STA 00A0H
	INX H
	INX B
	INX D
	LXI SP,00FFH
LOOP:	CALL PRIME
	INX H
	LDA 00A0H
	DCR A
	STA 00A0H
	JNZ LOOP
LBL:	HLT
PRIME:	PUSH PSW
	PUSH B
	PUSH D
	MOV B,M
	MVI D,00H
LOOP1:	MOV A,M
	CALL DIV
	MOV A,C
	ANA A
	JZ LBL3
	INR D
LBL3:	DCR B
	JNZ LOOP1
	MVI A,02H
	CMP D
	POP D
	POP B
	JC LBL4
	JNZ LBL4
	MOV A,M
	STAX B
	INX B
	LDA 00C0H
	INR A
	STA 00C0H
	JMP LBL5
LBL4:	MOV A,M
	STAX D
	INX D
	LDA 00D0H
	INR A
	STA 00D0H
LBL5:	POP PSW
	RET
DIV:	PUSH PSW
LOOP2:	CMP B
	JC LBL1
	SUB B
	JNC LOOP2
LBL1:	MVI C,00H
	ANA A
	JNZ LBL2
	MVI C,01H
LBL2:	POP PSW
	RET
