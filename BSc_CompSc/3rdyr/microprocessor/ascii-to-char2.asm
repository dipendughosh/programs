	LXI H,0050H
	MOV B,M
	INX H
	MOV C,M
	INX H
	MOV A,M
	CALL CONV
	INX H
	MVI M,8FH
	MVI B,41H
	MVI C,47H
	MVI D,30H
	MVI E,3AH
	CMP D
	JC LBL
	CMP E
	JNC LBL1
	SUB D
	JMP LBL2
LBL1:	CMP B
	JC LBL
	CMP C
	JNC LBL
	SUB B
	ADI 0AH
LBL2:	MOV M,A
LBL:	HLT
CONV:	ANA B
	RAR
	RAR
	RAR
	RAR
	MOV B,A
	MOV A,M
	ANA C
	MOV C,A
	MVI D,0AH
	CALL MULT
	ADD C
	RET
MULT:	XRA A
	MOV E,A
LOOP:	ADD B
	DCR D
	JNZ LOOP
	RET
