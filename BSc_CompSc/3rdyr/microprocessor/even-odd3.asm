	LXI H,0050H
	LXI B,0060H
	LXI SP,00AFH
	PUSH H
	PUSH B
	MOV D,M
	MVI E,00H
LOOP1:	INX H
	MOV A,M
	RAR
	JC LBL1
	RAL
	INX B
	STAX B
	INR E
LBL1:	DCR D
	JNZ LOOP1
	POP H
	MOV M,E
	POP H
	LXI B,0070H
	PUSH B
	MOV D,M
	MVI E,00H
LOOP2:	INX H
	MOV A,M
	RAR
	JNC LBL2
	RAL
	INX B
	STAX B
	INR E
LBL2:	DCR D
	JNZ LOOP2
	POP H
	MOV M,E
	HLT






