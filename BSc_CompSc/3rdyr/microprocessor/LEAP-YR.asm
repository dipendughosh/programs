	LXI H,0050H
	LXI D,0060H
	MVI A,03H
	STA 0080H
LOOP:	INX H
	MOV A,M
	ANI 0F0H
	RRC
	RRC
	RRC
	RRC
	MOV C,A
	MVI B,09H
LOOP1:	ADD C
	DCR B
	JNZ LOOP1
	MOV C,A
	MOV A,M
	ANI 0FH
	ADD C
	RAR
	JC LBL
	RAR
	JC LBL
	MVI A,01H
	JMP LBL2
LBL:	MVI A,00H
LBL2:	STAX D
	INX D
	INX H
	LDA 0080H
	DCR A
	STA 0080H
	JNZ LOOP
	HLT
