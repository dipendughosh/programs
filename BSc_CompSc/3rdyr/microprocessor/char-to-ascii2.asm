	LXI H,0050H
	MOV A,M
	INX H
	MVI M,8FH
	MVI B,00H
	MVI C,0AH
	MVI D,10H
	CMP B
	JC LBL
	CMP C
	JNC LBL1
	ADI 30H
	JMP LBL2
LBL1:	CMP D
	JNC LBL
	SUB C
	ADI 41H
LBL2:	CALL CONV
LBL:	HLT
CONV:	MVI B,64H
	CALL DIV
	MOV D,C
	MVI B,0AH
	CALL DIV
	MOV E,A
	MOV A,C
	ORA A
	RAL
	RAL
	RAL
	RAL
	ORA E
	MOV M,A
	RET
DIV:	MVI C,00H
LOOP:	CMP B
	JC LBL3
	SUB B
	INR C
	JMP LOOP
LBL3:	RET
