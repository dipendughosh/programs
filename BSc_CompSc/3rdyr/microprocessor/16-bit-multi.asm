	LHLD 0050H
	XCHG
	LHLD 0052H
	MOV B,H
	MOV C,L
	XRA A
	STA 0062H
	STA 0063H
	DCX D
	MOV A,E
	ORA D
	JZ LBL
LOOP:	DAD B
	JNC LBL1
	LDA 0062H
	ADI 01H
	STA 0062H
	JNC LBL1
	LDA 0063H
	INR A
	STA 0063H
LBL1:	DCX D
	MOV A,E
	ORA D
	JNZ LOOP
LBL:	SHLD 0060H
	HLT
