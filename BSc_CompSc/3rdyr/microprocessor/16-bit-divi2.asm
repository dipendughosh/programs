	LHLD 0050H
	LDA 0052H
	MOV D,A
	MVI B,00H
	MOV C,B
LOOP:	MOV A,H
	CPI 00H
	JNZ LBL2
	MOV A,L
	CMP D
	JC LBL
	SUB D
	MOV L,A
	JMP LBL1
LBL2:	MOV A,L
	SUB D
	MOV L,A
	JNC LBL1
	DCR H
LBL1:	MOV A,B
	ADI 01
	MOV B,A
	JNC LBL3
	INR C
LBL3:	JMP LOOP
LBL:	MOV A,B
	STA 0053H
	MOV A,C
	STA 0054H
	MOV A,L
	STA 0055H
	HLT

