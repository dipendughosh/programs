	LXI H,0050H
	MOV D,M
	INX H
	DCR D
	MOV B,M
LOOP1:	INX H
	MOV A,M
	CMP B
	JC LBL1
	MOV B,A
LBL1:	DCR D
	JNZ LOOP1
	LXI H,0050H
	MOV D,M
	INX H
	DCR D
	MOV C,M
	MOV A,M
	CMP B
	JNZ LOOP2
	INX H
	DCR D
	MOV C,M
LOOP2:	INX H
	MOV A,M
	CMP B
	JZ LBL2
	CMP C
	JC LBL2
	MOV C,A
LBL2:	DCR D
	JNZ LOOP2
	HLT
