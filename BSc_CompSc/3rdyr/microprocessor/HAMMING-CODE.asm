	LXI H,0050H
	XRA A
	MOV B,A
	MOV A,M
	ANI 0F0H
	JPE LBL1
	STC
	JMP LBL2
LBL1:	ORA A
LBL2:	MOV A,B
	RAL
	MOV B,A
	MOV A,M
	ANI 8EH
	JPE LBL3
	STC
	JMP LBL4
LBL3:	ORA A
LBL4:	MOV A,B
	RAL
	MOV B,A
	MOV A,M
	ANI 6DH
	JPE LBL5
	STC
	JMP LBL6
LBL5:	ORA A
LBL6:	MOV A,B
	RAL
	MOV B,A
	MOV A,M
	ANI 5BH
	JPE LBL7
	STC
	JMP LBL8
LBL7:	ORA A
LBL8:	MOV A,B
	RAL
	MOV B,A
	INX H
	MOV M,B
	HLT

