	LXI H,0050H
	MVI B,0AH
	MVI C,00H
	LXI D,0080H
	MOV A,M
	STAX D
	INX D
	MVI A,01H
	STAX D
	INR C
	MOV A,C
	STA 0100H
	DCR B
LOOP:	INX H
	LDA 0100H
	MOV C,A
	LXI D,0080H
LBL:	LDAX D
	CMP M
	JZ LBL2
	INX D
	INX D
	DCR C
	JNZ LBL
	LDA 0100H
	INR A
	STA 0100H
	MOV A,M
	STAX D
	INX D
	MVI A,01H
	STAX D
	JMP LBL3
LBL2:	INX D
	LDAX D
	INR A
	STAX D
LBL3:	DCR B
	JNZ LOOP
	HLT