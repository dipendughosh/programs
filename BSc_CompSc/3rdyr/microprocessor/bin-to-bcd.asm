	LXI H,0050H
	MVI B,64H
	MOV A,M
	CALL DIV
	MOV D,C
	MVI B,0AH
	CALL DIV
	MOV E,A
	MOV A,C
	ORA A
	RAL
	RAL
	RAL
	RAL
	ORA E
	INX H
	MOV M,D
	INX H
	MOV M,A
	HLT
DIV:	MVI C,00H
LOOP:	CMP B
	JC LBL1
	SUB B
	INR C
	JMP LOOP
LBL1:	RET
