	LXI B,0150H
	LXI D,0170H
	LXI H,0190H
	LXI SP,020FH
	LDAX B
	PUSH B
	MOV B,A
	LDAX D
	ADD B
	MOV M,A
	STA 01FFH
	MOV A,B
	STA 01FEH
	LDAX D
	STA 01FDH
	POP B
	INX B
	INX D
	INX H
LOOP:	LDAX B
	PUSH B
	MOV B,A
	LDAX D
	CMP B
	JNZ LS_D
	MOV M,A
	INX H
	MOV M,B
	INX H
	POP B
	INX B
	INX D
	LDA 01FEH
	PUSH B
	DCR A
	STA 01FEH
	MOV B,A
	LDA 01FDH
	DCR A
	STA 01FDH
	ORA A
	JZ B_LFT
	MOV A,B
	POP B
	ORA A
	JZ D_LFT
	LDA 01FFH
	DCR A
	DCR A
	JNZ LOOP
LS_D:	JNC LS_B
	MOV M,A
	INX H
	INX D
	LDA 01FDH
	DCR A
	STA 01FDH
	ORA A
	JZ B_LFT
	JMP CONDI
LS_B:	MOV M,B
	INX H
	POP B
	INX B
	LDA 01FEH
	DCR A
	STA 01FEH
	ORA A
	JZ D_LFT
	JMP CONDI
CONDI:	LDA 01FFH
	DCR A
	STA 01FFH
	JNZ LOOP
B_LFT:	LDA 01FEH
	ORA A
	JZ STP
	DCR A
	STA 01FEH
	LDAX B
	MOV M,A
	INX B
	INX H
	JMP B_LFT
D_LFT:	LDA 01FDH
	ORA A
	JZ STP
	DCR A
	STA 01FDH
	LDAX D
	MOV M,A
	INX D
	INX H
	JMP D_LFT
STP:	HLT
