	LDA 0090H
	LXI H,00A0H
	MOV B,A
	ANA A
	RAR
	STA 0091H
	MVI C,01H
LOOP:	CALL DIV
	MOV A,D
	CPI 01H
	JNZ LBL
	CALL PRIME
LBL:	INR C
	LDA 0091H
	CMP C
	JNC LOOP
	HLT

DIV:	MOV A,B
LOOP1:	CMP C
	JC LBL2
	JZ LBL1
	SUB C
	JMP LOOP1
LBL1:	MVI D,01H
	RET
LBL2:	MVI D,00H
	RET

PRIME:	MVI E,00H
	MVI D,01H
LOOP3:	MOV A,C
LOOP2:	CMP D
	JC LBL4
	JZ LBL3
	SUB D
	JMP LOOP2
LBL3:	INR E
LBL4:	INR D
	MOV A,C
	CMP D
	JNC LOOP3
	MOV A,E
	CPI 02H
	JNZ LBL5
	MOV M,C
	INX H
LBL5:	RET





