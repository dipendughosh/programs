	LXI SP,00FFH
	LXI H,0050H
	LXI D,0080H
	MOV B,M
LOOP:	INX H
	CALL DIV
	MOV A,C
	CPI 02H
	JNZ LBL
	MOV A,M
	STAX D
	INX D
LBL:	DCR B
	JNZ LOOP
	HLT
DIV:	PUSH D
	MVI C,01H
	MVI E,00H
LOOP2:	MOV A,M
LOOP3:	CMP C
	JC LBL2
	JZ LBL1
	SUB C
	JMP LOOP3
LBL1:	INR E
LBL2:	INR C
	MOV A,M
	CMP C
	JC LBL3
	JMP LOOP2
LBL3:	MOV C,E
	POP D
	RET
