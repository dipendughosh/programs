	LHLD 0050H
	MVI C,00H
	MVI D,00H
	MVI B,08H
	MOV A,L
LOOP1:	RAR
	JC LBL1
	INR D
	JMP LBL2
LBL1:	INR C
LBL2:	DCR B
	JNZ LOOP1
	MVI B,08H
	MOV A,H
LOOP2:	RAR
	JC LBL3
	INR D
	JMP LBL4
LBL3:	INR C
LBL4:	DCR B
	JNZ LOOP2
	MOV A,D
	STA 0052H
	MOV A,C
	STA 0053H
	HLT
