	LXI H,0100H
	MVI B,0AH
	MOV C,M
	DCR B
	MVI D,00
	MOV A,M
	STA 0120H
	STA 0121H
LOOP1:	INX H
	MOV A,C
	ADD M
	MOV C,A
	JNC LBL
	INR D
LBL:	LDA 0120H
	CMP M
	JNC LBL1
	MOV A,M
	STA 0120H
LBL1:	LDA 0121H
	CMP M
	JC LBL2
	MOV A,M
	STA 0121H
LBL2:	DCR B
	JNZ LOOP1
	INX H
	LDA 0120H
	MOV M,A
	INX H
	LDA 0121H
	MOV M,A
	INX H
	MOV A,D
	MOV M,A
	STA 0130H
	INX H
	MOV A,C
	MOV M,A
	STA 0131H
	MVI B,0AH
	MVI D,00H
	MOV E,D
LOOP2:	MVI C,00H
	LDA 0130H
	CPI 00H
	JZ LBL4
	LDA 0131H
	SUB B
	STA 0131H
	JNC LBL3
	INR C
LBL3:	LDA 0130H
	SUB C
	STA 0130H
	MOV A,D
	ADI 01H
	MOV D,A
	JNC LBL5
	INR E
LBL5:	JMP LOOP2
LBL4:	LDA 0131H
	CMP B
	JC LBL7
	SUB B
	STA 0131H
	MOV A,D
	ADI 01H
	MOV D,A
	JNC LBL6
	INR E
LBL6:	LDA 0131H
	ORA A
	JZ LBL7
	JMP LBL4
LBL7:	MOV B,A
	INX H
	MOV M,E
	INX H
	MOV M,D
	INX H
	MOV M,B
	HLT
