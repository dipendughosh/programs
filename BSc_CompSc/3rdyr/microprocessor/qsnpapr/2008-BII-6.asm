	LXI H,0050H
	LXI D,0060H
	MVI B,0AH
	MOV C,B
LOOP:	MOV A,M
	STAX D
	MOV A,E
	ADD C
	MOV E,A
	MOV A,M
	CPI 00H
	JNZ LBL1
	INR A
	STAX D
	JMP LBL
LBL1:	CPI 01H
	JNZ LBL2
	DCR A
	STAX D
	JMP LBL
LBL2:	STAX D
LBL:	MOV A,E
	SUB C
	MOV E,A
	INX H
	INX D
	DCR B
	JNZ LOOP
	HLT


