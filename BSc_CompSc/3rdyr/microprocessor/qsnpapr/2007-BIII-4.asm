	LXI H,0080H
	LXI D,0060H
	MVI A,04H
	STA 0070H
LOOP:	MOV A,M
	ANI 0F0H
	RRC
	RRC
	RRC
	RRC
	MOV C,A
	MVI B,09H
LOOP1:	ADD C
	DCR B
	JNZ LOOP1
	MOV C,A
	MOV A,M
	ANI 0FH
	ADD C
	STAX D
	INX D
	INX H
	LDA 0070H
	DCR A
	STA 0070H
	JNZ LOOP
	XRA A
	MOV C,A
	MVI B,04H
	LXI H,0060H
LOOP2:	ADD M
	JNC LBL
	INR C
LBL:	DCR B
	JNZ LOOP2
	MOV H,C
	MOV L,A
	XRA A
	MOV B,H
	MOV C,L
	DAD H
	JNC LBL1
	INR A
LBL1:	DAD B
	JNC LBL2
	INR A
LBL2:	SHLD 0070H
	STA 0072H
	HLT