	LXI H,0070H
	MVI B,0AH
	XRA A
	MOV C,A
LOOP1:	INX H
	ADD M
	JNC LBL
	INR C
LBL:	DCR B
	JNZ LOOP1
	STA 0081H
	MOV A,C
	STA 0080H
	MVI B,0AH
	MVI D,00H
	MOV E,D
LOOP2:	MVI C,00H
	LDA 0080H
	CPI 00H
	JZ LBL1
	LDA 0081H
	SUB B
	STA 0081H
	JNC LBL2
	INR C
LBL2:	LDA 0080H
	SUB C
	STA 0080H
	MOV A,D
	ADI 01H
	MOV D,A
	JNC LBL3
	INR E
LBL3:	JMP LOOP2
LBL1:	LDA 0081H
	CMP B
	JC LBL4
	SUB B
	STA 0081H
	MOV A,D
	ADI 01H
	MOV D,A
	JNC LBL6
	INR E
LBL6:	LDA 0081H
	ORA A
	JZ LBL4
LBL5:	JMP LBL1
LBL4:	STA 0082H
	MOV A,D
	STA 0081H
	MOV A,E
	STA 0080H
	HLT
