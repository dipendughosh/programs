	LXI H,0050H
	MVI B,05H
	MVI C,00H
	MOV D,C
	MOV A,C
	STA 0080H
	STA 0082H
LOOP:	LDA 0080H
	ADD M
	STA 0080H
	JNC LBL1
	INR C
LBL1:	INX H
	LDA 0082H
	ADD M
	STA 0082H
	JNC LBL2
	INR D
LBL2:	INX H
	DCR B
	JNZ LOOP
	MOV A,C
	STA 0081H
	MOV A,D
	STA 0083H
	HLT

