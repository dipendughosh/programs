	LXI H,0050H
	MVI B,0AH
	MVI A,00H
	STA 005BH
	STA 005DH
	MOV C,A
	MOV D,A
LOOP:	MOV A,M
	RAL
	JC LBL1
	RAR
	ADD D
	MOV D,A
	JNC LBL2
	LDA 005BH
	INR A
	STA 005BH
	JMP LBL2
LBL1:	RAR
	ADD C
	MOV C,A
	JNC LBL2
	LDA 005DH
	INR A
	STA 005DH
LBL2:	INX H
	DCR B
	JNZ LOOP
	MOV M,D
	INX H
	INX H
	MOV M,C
	HLT

