	LDA 0050H
	MOV B,A
	ANI 0F0H
	RRC
	RRC
	RRC
	RRC
	MOV D,A
	MVI C,09H
LOOP:	ADD D
	DCR C
	JNZ LOOP
	MOV C,A
	MOV A,B
	ANI 0FH
	ADD C
	CPI 41H
	JC LBL
	CPI 47H
	JNC LBL
	SUI 37H
	JMP LBL2
LBL:	CPI 30H
	JC LBL1
	CPI 3BH
	JNC LBL1
	SUI 30H
	JMP LBL2
LBL1:	MVI A,00H
LBL2:	STA 0051H
	HLT
