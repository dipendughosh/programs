	LXI H,0070H
	MVI B,0CH
	MOV A,M
	DCR B
LOOP1:	INX H
	CMP M
	JC LBL1
	JZ LBL1
	MOV A,M
LBL1:	DCR B
	JNZ LOOP1
	MOV D,A
	LXI H,0070H
	MVI B,0CH
	MOV A,M
	DCR B
	CMP D
	JNZ LOOP2
	INX H
	MOV A,M
	DCR B
LOOP2:	INX H
	CMP M
	JC LBL2
	JZ LBL2
	MOV C,A
	MOV A,M
	CMP D
	JNZ LBL2
	MOV A,C
LBL2:	DCR B
	JNZ LOOP2
	MOV E,A
	LXI H,0070H
	MVI B,0CH
	MOV A,M
	DCR B
LBL4:	CMP D
	JNZ LBL3
	INX H
	MOV A,M
	DCR B
LBL3:	CMP E
	JNZ LOOP3
	INX H
	MOV A,M
	DCR B
	JMP LBL4
LOOP3:	INX H
	CMP M
	JC LBL6
	JZ LBL6
	MOV C,A
	MOV A,M
	CMP D
	JNZ LBL5
	MOV A,C
LBL5:	CMP E
	JNZ LBL6
	MOV A,C
LBL6:	DCR B
	JNZ LOOP3
	INX H
	MOV M,A
	HLT

