	LDA 0050H
	MVI B,00H
	MOV C,B
	MVI D,08H
LOOP:	RAL
	JNC LBL1
	INR B
	JMP LBL
LBL1:	INR C
LBL:	DCR D
	JNZ LOOP
	MOV A,B
	STA 0051H
	MOV A,C
	STA 0052H
	LXI H,0060H
	MVI B,00H
	MOV C,B
	MOV D,M
LOOP1:	INX H
	MOV A,M
	RAR
	JC LBL2
	INR B
	JMP LBL3
LBL2:	INR C
LBL3:	DCR D
	JNZ LOOP1
	INX H
	MOV M,B
	INX H
	MOV M,C
	HLT
