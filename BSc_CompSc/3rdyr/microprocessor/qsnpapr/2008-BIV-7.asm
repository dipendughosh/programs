	LXI H,0050H
	MVI B,0AH
LOOP1:	MOV C,B
	MOV D,H
	MOV E,L
LOOP2:	LDAX D
	CMP M
	JNC LBL1
	STA 0090H
	MOV A,M
	STAX D
	LDA 0090H
	MOV M,A
LBL1:	INX D
	DCR C
	JNZ LOOP2
	INX H
	DCR B
	JNZ LOOP1
	LDA 0050H
	STA 0060H
	LDA 0059H
	STA 0061H
	LXI H,0050H
	MOV A,M
	STA 0070H
	MOV A,L
	ADI 0AH
	MOV L,A
	MOV A,M
	STA 0071H
	HLT
