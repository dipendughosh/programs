	LXI H,0080H
	LXI D,0090H
	LXI B,0100H
	XRA A
	STAX D
	STAX B
	MOV A,M
	STA 0070H
	INX D
	INX B
LOOP:	INX H
	MOV A,M
	RAL
	JNC LBL
	RAR
	STAX B
	INX B
	LDA 0100H
	INR A
	STA 0100H
	JMP LBL1
LBL:	RAR
	STAX D
	INX D
	LDA 0090H
	INR A
	STA 0090H
LBL1:	LDA 0070H
	DCR A
	STA 0070H
	JNZ LOOP
	HLT




