	LHLD 0050H
	LDA 0052H
	MOV D,A
	MVI B,00H
	MVI E,00H
LOOP:	MVI C,00H
	MOV A,H
	CPI 00H
	JZ LBL1
	MOV A,B
	ADI 01H
	MOV B,A
	JNC LBL2
	INR E
LBL2:	MOV A,L
	SUB D
	MOV L,A
	JNC LBL3
	INR C
LBL3:	MOV A,H
	SUB C
	MOV H,A
	JMP LOOP
LBL1:	MOV A,L
	CMP D
	JC LBL4
	MOV A,B
	ADI 01H
	MOV B,A
	JNC LBL5
	INR E
LBL5:	MOV A,L
	SUB D
	MOV L,A
	JNZ LBL1
LBL4:	MOV A,L
	STA 0053H
	MOV A,B
	STA 0054H
	MOV A,E
	STA 0055H
	HLT
