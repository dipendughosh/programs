	LDA 0050H
	CPI 00H
	JC LBL
	CPI 09
	JNC LBL3
	ADI 30
	JMP LBL4
LBL3:	CPI 10H
	JNC LBL
	ADI 37H
LBL4:	MVI B,00H
	MVI C,0AH
LOOP:	CMP C
	JC LBL1
	INR B
	SUB C
	JNZ LOOP
LBL1:	MOV C,A
	MOV A,B
	RLC
	RLC
	RLC
	RLC
	ORA C
	JMP LBL2
LBL:	MVI A,00H
LBL2:	STA 0051H
	HLT
