	LXI H,0070H
	LXI D,0080H
	MVI B,03H
	XRA A
	MOV C,A
LOOP1:	ADD M
	JNC LBL1
	INR C
LBL1:	CALL REV
	INX H
	DCR B
	JNZ LOOP1
	MVI M,00H
	MVI D,03H
	MOV B,A
LOOP3:	MVI E,00H
	MOV A,C
	CPI 00H
	JZ LBL3
	MOV A,B
	SUB D
	MOV B,A
	JNC LBL2
	INR E
LBL2:	MOV A,C
	SUB E
	MOV C,A
	INR M
	JMP LOOP3
LBL3:	MOV A,B
LBL5:	CMP D
	JC LBL4
	SUB D
	INR M
	ORA A
	JZ LBL4
	JMP LBL5
LBL4:	INX H
	MOV M,A
	HLT
REV:	PUSH PSW
	PUSH B
	MVI B,08H
	MOV A,M
	STA 0090H
LOOP2:	LDA 0090H
	RAL
	STA 0090H
	LDA 0091H
	RAR
	STA 0091H
	DCR B
	JNZ LOOP2
	LDA 0091H
	STAX D
	INX D
	POP B
	POP PSW
	RET
