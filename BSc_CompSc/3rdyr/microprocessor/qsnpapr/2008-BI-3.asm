	LXI H,0120H
	MOV A,M
	STA 0110H
	LXI D,0130H
	LDAX D
	STA 0111H
	ADD M
	STA 0112H
	LXI B,0140H
	STAX B
	INX H
	INX D
	INX B
LOOP:	LDAX D
	CMP M
	JNZ LBL1
	STAX B
	INX B
	STAX B
	INX H
	INX D
	INX B
	LDA 0112H
	DCR A
	DCR A
	STA 0112H
	JZ OUT
	LDA 0110H
	DCR A
	STA 0110H
	JZ D_LFT
	LDA 0111H
	DCR A
	STA 0111H
	JZ H_LFT
LBL1:	JNC LBL2
	STAX B
	INX B
	INX D
	LDA 0112H
	DCR A
	STA 0112H
	JZ OUT
	LDA 0111H
	DCR A
	STA 0111H
	JZ H_LFT
LBL2:	MOV A,M
	STAX B
	INX B
	INX H
	LDA  0112H
	DCR A
	STA 0112H
	JZ OUT
	LDA 0110H
	DCR A
	STA 0110H
	JZ D_LFT
	JMP LOOP
D_LFT:	LDAX D
	STAX B
	INX D
	INX B
	LDA 0112H
	DCR A
	STA 0112H
	JZ OUT
	LDA 0111H
	DCR A
	STA 0111H
	JNZ D_LFT
	JMP OUT
H_LFT:	MOV A,M
	STAX B
	INX H
	INX B
	LDA 0112H
	DCR A
	STA 0112H
	JZ OUT
	LDA 0110H
	DCR A
	STA 0110H
	JNZ H_LFT
OUT:	HLT