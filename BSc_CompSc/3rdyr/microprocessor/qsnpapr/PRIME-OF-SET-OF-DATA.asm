	LXI SP,0AFFH
	LXI D,00F0H
	LXI H,00E0H
	MOV A,M
	STA 0A20H
LOOP:	INX H
	CALL DIV
	CPI 02H
	JNZ LBL
	MOV A,M
	STAX D
	INX D
LBL:	LDA 0A20H
	DCR A
	STA 0A20H
	JNZ LOOP
	HLT

DIV:	PUSH H
	PUSH D
	MVI E,00H
	MVI C,01H
LOOP1:	MOV A,M
LOOP2:	CMP C
	JC LBL1
	JZ LBL2
	SUB C
	JMP LOOP2
LBL2:	INR E
LBL1:	INR C
	MOV A,M
	CMP C
	JC LBL3
	JMP LOOP1
LBL3:	MOV A,E
	POP D
	POP H
	RET