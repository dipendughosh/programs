	LDA 0050H
	MOV B,A
	ANI 0F0H
	RRC
	RRC
	RRC
	RRC
	CPI 09H
	JZ LBL
	JC LBL
	MVI A,00H
	STA 0051H
	JMP LBL1
LBL:	MVI A,01H
	STA 0051H
LBL1:	MOV A,B
	ANI 0FH
	CPI 09H
	JZ LBL2
	JC LBL2
	MVI A,00H
	STA 0052H
	JMP LBL3
LBL2:	MVI A,01H
	STA 0052H
LBL3:	HLT
