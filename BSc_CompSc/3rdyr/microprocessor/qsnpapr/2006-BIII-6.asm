	LHLD 0090H
	XCHG
	LHLD 0092H
	MOV B,H
	MOV C,L
	XRA A
	STA 00A2H
	STA 00A3H
	DCX D
	MOV A,E
	ORA D
	JZ LBL
LOOP:	DAD B
	JNC LBL1
	LDA 00A2H
	ADI 01H
	STA 00A2H
	JNC LBL1
	LDA 00A3H
	INR A
	STA 00A3H
LBL1:	DCX D
	MOV A,E
	ORA D
	JNZ LOOP
LBL:	SHLD 00A0H
	LHLD 0090H
	CALL DIV
	STA 00B0H
	MOV A,B
	STA 00B1H
	LHLD 0092H
	CALL DIV
	STA 00B2H
	MOV A,B
	STA 00B3H
	HLT
DIV:	MVI B,00H
	MVI D,10H
LOOP1:	MVI C,00H
	MOV A,H
	CPI 00H
	JZ LBL2
	MOV A,L
	INR B
	SUB D
	MOV L,A
	JNC LBL3
	INR C
LBL3:	MOV A,H
	SUB C
	MOV H,A
	JMP LOOP1
LBL2:	MOV A,L
LOOP2:	CMP D
	JC LBL4
	INR B
	SUB D
	JNZ LOOP2
LBL4:	RET