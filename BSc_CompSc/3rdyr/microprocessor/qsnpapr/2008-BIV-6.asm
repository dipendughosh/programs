	LDA 0050H
	MOV B,A
	LDA 0051H
	MOV D,A
	MVI C,00H
	DCR B
LOOP1:	ADD D
	JNC LBL1
	INR C
LBL1:	DCR B
	JNZ LOOP1
	STA 0053H
	MOV A,C
	STA 0052H
	LDA 0050H
	MOV B,A
	LDA 0051H
	CMP B
	JNC LBL2
	MOV D,A
	MOV A,B
	MOV B,D
LBL2:	MVI C,00H
LOOP2:	CMP B
	JC LBL3
	INR C
	SUB B
	JNZ LOOP2
LBL3:	STA 0055H
	MOV A,C
	STA 0054H
	HLT


