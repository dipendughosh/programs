	LXI D,0060H
	LXI H,0050H
	MVI B,0AH
LOOP1:	MOV A,M
	CALL PALLIN
	INX H
	DCR B
	JNZ LOOP1
	HLT
PALLIN:	MVI C,08H
	STA 0080H
LOOP2:	LDA 0080H
	RAL
	STA 0080H
	LDA 0090H
	RAR
	STA 0090H
	DCR C
	JNZ LOOP2
	LDA 0090H
	CMP M
	JNZ LBL
	STAX D
	INX D
LBL:	RET
