	LXI H,0050H
	MOV B,M
	INX H
	MOV C,M
	INX H
	MOV A,M
	ANA B
	RAR
	RAR
	RAR
	RAR
	MOV B,A
	MOV A,M
	ANA C
	MOV C,A
	MVI D,0AH
	CALL MULT
	ADD C
	INX H
	MOV M,A
	HLT
MULT:	XRA A
	MOV E,A
LOOP:	ADD B
	DCR D
	JNZ LOOP
	RET

