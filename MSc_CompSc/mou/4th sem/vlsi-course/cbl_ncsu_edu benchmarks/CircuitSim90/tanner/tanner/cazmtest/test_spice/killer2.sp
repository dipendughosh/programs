*killer2z sPice testrUn - from accUsim inPUt
.OPTION LIMPTS=10000
.OPTION ITL1=500
*
*
VDD 19 0 DC 5
*
R1 1 2 22K
R2 2 3 22K
R3 3 4 22K
*
C1 2 0 1PF
C2 3 0 1PF
C3 4 0 1PF
*
MN1 1 4 0 0 N_OSC W=50U L=3U
MP1 1 4 19 19 P_OSC W=150U L=3U
*
MN2 5 1 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP2 5 1 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MN3 12 5 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
*
MN4 12 11 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP3 17 11 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MP4 12 5 17 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MN5 13 12 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP5 13 12 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MN6 14 13 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP6 14 13 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MN7 15 14 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP7 15 14 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MN8 16 15 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP8 16 15 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MN9 6 5 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP9 6 5 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MN10 7 6 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
*
MN11 7 16 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP10 18 16 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MP11 7 6 18 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MN12 8 7 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP12 8 7 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MN13 9 8 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP13 9 8 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MN14 10 9 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP14 10 9 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
MN15 11 10 0 0 MN W=8U L=3U AD=100P AS=100P PD=32U PS=32U
MP15 11 10 19 19 MP W=24U L=3U AD=150P AS=150P PD=75U PS=75U
*
C1X 1 0 90E-15
C5 5 0 90E-15
C6 6 0 90E-15
C7 7 0 90E-15
C8 8 0 90E-15
C9 9 0 90E-15
C10 10 0 100E-15
C11 11 0 90E-15
C12 12 0 90E-15
C13 13 0 90E-15
C14 14 0 90E-15
C15 15 0 90E-15
C16 16 0 100E-15
C17 17 0 90E-15
C18 18 0 90E-15
*
*
.MODEL N_OSC NMOS(LEVEL=1 VTO= +1.25 KP=39E-6 LAMBDA=.001)
.MODEL P_OSC PMOS(LEVEL=1 VTO= -1.25 KP=28E-6 LAMBDA=.001)
*
.MODEL MN NMOS(VTO=.75 KP=39U PHI=.69 GAMMA=0 RD=20 RS=20
+ JS=10E-9 CJ=200U CJSW=350E-12 MJ=.47 MJSW=.3 CGSO=280P CGDO=280P
+ CGBO=140P NSUB=1E16 NFS=100E9 TOX=525E-10 XJ=500E-9 UO=550
+ LEVEL=1 TPG= +1)
*
.MODEL MP PMOS(VTO=-.75 KP=14U PHI=.63 GAMMA=0 RD=20 RS=20
+ JS=10E-9 CJ=200U CJSW=300E-12 MJ=.45 MJSW=.3 CGSO=280P CGDO=280P
+ CGBO=140P NSUB=3E15 NFS=100E9 TOX=525E-10 XJ=500E-9 UO=200
+ LEVEL=1 TPG= -1)
*
.TEMP 2.7E+01
.OPT ACCT
.PRINT TRAN V(4) V(11) V(16)
.TRAN 5.E-10 1.E-06 UIC
.END
