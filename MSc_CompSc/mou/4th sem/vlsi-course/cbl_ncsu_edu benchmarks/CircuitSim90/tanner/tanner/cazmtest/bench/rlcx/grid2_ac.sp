TITLE 	Smallrb
T24          36           0 0 0  z0 = 0.62873E+08 f=1.0e-9 nl=.25
RT25          35          36      0.46160E-02
VT25          34          35 AC   0.00000E+00
LT25          33          34      0.95753E-09
CT26          39           0      0.48472E-13
RT26          39           0      0.62873E+08
RT27          38          39      0.46160E-02
VT27          37          38 AC   0.00000E+00
LT27          36          37      0.95753E-09
CT28          40           0      0.48472E-13
RT28          40           0      0.62873E+08
CT29          43           0      0.26987E-13
RT29          43           0      0.62873E+08
RT30          42          43      0.46160E-02
VT30          41          42 AC   0.00000E+00
LT30          40          41      0.95753E-09
CT31          46           0      0.26987E-13
RT31          46           0      0.62873E+08
RT32          45          46      0.46160E-02
VT32          44          45 AC   0.00000E+00
LT32          43          44      0.95753E-09
CT33          49           0      0.26987E-13
RT33          49           0      0.62873E+08
RT34          48          49      0.46160E-02
VT34          47          48 AC   0.00000E+00
LT34          46          47      0.95753E-09
CT35          52           0      0.48472E-13
RT35          52           0      0.62873E+08
RT36          51          52      0.46160E-02
VT36          50          51 AC   0.00000E+00
LT36          49          50      0.95753E-09
CT37          53           0      0.48472E-13
RT37          53           0      0.62873E+08
CT38          56           0      0.26987E-13
RT38          56           0      0.62873E+08
RT39          55          56      0.46160E-02
VT39          54          55 AC   0.00000E+00
LT39          53          54      0.95753E-09
CT40          59           0      0.26987E-13
RT40          59           0      0.62873E+08
RT41          58          59      0.46160E-02
VT41          57          58 AC   0.00000E+00
LT41          56          57      0.95753E-09
CT42          62           0      0.26987E-13
RT42          62           0      0.62873E+08
RT43          61          62      0.46160E-02
VT43          60          61 AC   0.00000E+00
LT43          59          60      0.95753E-09
CT44          65           0      0.48472E-13
RT44          65           0      0.62873E+08
RT45          64          65      0.46160E-02
VT45          63          64 AC   0.00000E+00
LT45          62          63      0.95753E-09
CT46          66           0      0.48472E-13
RT46          66           0      0.62873E+08
CT47          69           0      0.26987E-13
RT47          69           0      0.62873E+08
RT48          68          69      0.46160E-02
VT48          67          68 AC   0.00000E+00
LT48          66          67      0.95753E-09
CT49          72           0      0.26987E-13
RT49          72           0      0.62873E+08
RT50          71          72      0.46160E-02
VT50          70          71 AC   0.00000E+00
LT50          69          70      0.95753E-09
CT51          75           0      0.26987E-13
RT51          75           0      0.62873E+08
RT52          74          75      0.46160E-02
VT52          73          74 AC   0.00000E+00
LT52          72          73      0.95753E-09
CT53          78           0      0.48472E-13
RT53          78           0      0.62873E+08
RT54          77          78      0.46160E-02
VT54          76          77 AC   0.00000E+00
LT54          75          76      0.95753E-09
CT55          79           0      0.48472E-13
RT55          79           0      0.62873E+08
CT56          82           0      0.26987E-13
RT56          82           0      0.62873E+08
RT57          81          82      0.46160E-02
VT57          80          81 AC   0.00000E+00
LT57          79          80      0.95753E-09
CT58          85           0      0.26987E-13
RT58          85           0      0.62873E+08
RT59          84          85      0.46160E-02
VT59          83          84 AC   0.00000E+00
LT59          82          83      0.95753E-09
CT60          88           0      0.26987E-13
RT60          88           0      0.62873E+08
RT61          87          88      0.46160E-02
VT61          86          87 AC   0.00000E+00
LT61          85          86      0.95753E-09
CT62          91           0      0.48472E-13
RT62          91           0      0.62873E+08
RT63          90          91      0.46160E-02
VT63          89          90 AC   0.00000E+00
LT63          88          89      0.95753E-09
CT64          92           0      0.48472E-13
RT64          92           0      0.62873E+08
CT65          95           0      0.26987E-13
RT65          95           0      0.62873E+08
RT66          94          95      0.46160E-02
VT66          93          94 AC   0.00000E+00
LT66          92          93      0.95753E-09
CT67          98           0      0.26987E-13
RT67          98           0      0.62873E+08
RT68          97          98      0.46160E-02
VT68          96          97 AC   0.00000E+00
LT68          95          96      0.95753E-09
CT69         101           0      0.26987E-13
RT69         101           0      0.62873E+08
RT70         100         101      0.46160E-02
VT70          99         100 AC   0.00000E+00
LT70          98          99      0.95753E-09
CT71         104           0      0.48472E-13
RT71         104           0      0.62873E+08
RT72         103         104      0.46160E-02
VT72         102         103 AC   0.00000E+00
LT72         101         102      0.95753E-09
CT73         105           0      0.48472E-13
RT73         105           0      0.62873E+08
CT74         108           0      0.26987E-13
RT74         108           0      0.62873E+08
RT75         107         108      0.46160E-02
VT75         106         107 AC   0.00000E+00
LT75         105         106      0.95753E-09
CT76         111           0      0.26987E-13
RT76         111           0      0.62873E+08
RT77         110         111      0.46160E-02
VT77         109         110 AC   0.00000E+00
LT77         108         109      0.95753E-09
CT78         114           0      0.26987E-13
RT78         114           0      0.62873E+08
RT79         113         114      0.46160E-02
VT79         112         113 AC   0.00000E+00
LT79         111         112      0.95753E-09
CT80         117           0      0.48472E-13
RT80         117           0      0.62873E+08
RT81         116         117      0.46160E-02
VT81         115         116 AC   0.00000E+00
LT81         114         115      0.95753E-09
CT82         118           0      0.48472E-13
RT82         118           0      0.62873E+08
CT83         121           0      0.26987E-13
RT83         121           0      0.62873E+08
RT84         120         121      0.46160E-02
VT84         119         120 AC   0.00000E+00
LT84         118         119      0.95753E-09
CT85         124           0      0.26987E-13
RT85         124           0      0.62873E+08
RT86         123         124      0.46160E-02
VT86         122         123 AC   0.00000E+00
LT86         121         122      0.95753E-09
CT87         127           0      0.26987E-13
RT87         127           0      0.62873E+08
RT88         126         127      0.46160E-02
VT88         125         126 AC   0.00000E+00
LT88         124         125      0.95753E-09
CT89         130           0      0.48472E-13
RT89         130           0      0.62873E+08
RT90         129         130      0.46160E-02
VT90         128         129 AC   0.00000E+00
LT90         127         128      0.95753E-09
CT91         131           0      0.48472E-13
RT91         131           0      0.62873E+08
CT92         134           0      0.26987E-13
RT92         134           0      0.62873E+08
RT93         133         134      0.46160E-02
VT93         132         133 AC   0.00000E+00
LT93         131         132      0.95753E-09
CT94         137           0      0.26987E-13
RT94         137           0      0.62873E+08
RT95         136         137      0.46160E-02
VT95         135         136 AC   0.00000E+00
LT95         134         135      0.95753E-09
CT96         140           0      0.26987E-13
RT96         140           0      0.62873E+08
RT97         139         140      0.46160E-02
VT97         138         139 AC   0.00000E+00
LT97         137         138      0.95753E-09
CT98         143           0      0.48472E-13
RT98         143           0      0.62873E+08
RT99         142         143      0.46160E-02
VT99         141         142 AC   0.00000E+00
LT99         140         141      0.95753E-09
CT100         144           0      0.48472E-13
RT100         144           0      0.62873E+08
CT101         147           0      0.26987E-13
RT101         147           0      0.62873E+08
RT102         146         147      0.46160E-02
VT102         145         146 AC   0.00000E+00
LT102         144         145      0.95753E-09
CT103         150           0      0.26987E-13
RT103         150           0      0.62873E+08
RT104         149         150      0.46160E-02
VT104         148         149 AC   0.00000E+00
LT104         147         148      0.95753E-09
CT105         153           0      0.26987E-13
RT105         153           0      0.62873E+08
RT106         152         153      0.46160E-02
VT106         151         152 AC   0.00000E+00
LT106         150         151      0.95753E-09
CT107         156           0      0.48472E-13
RT107         156           0      0.62873E+08
RT108         155         156      0.46160E-02
VT108         154         155 AC   0.00000E+00
LT108         153         154      0.95753E-09
CT109         157           0      0.48472E-13
RT109         157           0      0.62873E+08
CT110         160           0      0.26987E-13
RT110         160           0      0.62873E+08
RT111         159         160      0.46160E-02
VT111         158         159 AC   0.00000E+00
LT111         157         158      0.95753E-09
CT112         163           0      0.26987E-13
RT112         163           0      0.62873E+08
RT113         162         163      0.46160E-02
VT113         161         162 AC   0.00000E+00
LT113         160         161      0.95753E-09
CT114         166           0      0.26987E-13
RT114         166           0      0.62873E+08
RT115         165         166      0.46160E-02
VT115         164         165 AC   0.00000E+00
LT115         163         164      0.95753E-09
CT116         169           0      0.48472E-13
RT116         169           0      0.62873E+08
RT117         168         169      0.46160E-02
VT117         167         168 AC   0.00000E+00
LT117         166         167      0.95753E-09
CT118         170           0      0.48472E-13
RT118         170           0      0.62873E+08
CT119         173           0      0.26987E-13
RT119         173           0      0.62873E+08
RT120         172         173      0.46160E-02
VT120         171         172 AC   0.00000E+00
LT120         170         171      0.95753E-09
CT121         176           0      0.26987E-13
RT121         176           0      0.62873E+08
RT122         175         176      0.46160E-02
VT122         174         175 AC   0.00000E+00
LT122         173         174      0.95753E-09
CT123         179           0      0.26987E-13
RT123         179           0      0.62873E+08
RT124         178         179      0.46160E-02
VT124         177         178 AC   0.00000E+00
LT124         176         177      0.95753E-09
CT125         182           0      0.48472E-13
RT125         182           0      0.62873E+08
RT126         181         182      0.46160E-02
VT126         180         181 AC   0.00000E+00
LT126         179         180      0.95753E-09
CT127         183           0      0.48472E-13
RT127         183           0      0.62873E+08
CT128         186           0      0.26987E-13
RT128         186           0      0.62873E+08
RT129         185         186      0.46160E-02
VT129         184         185 AC   0.00000E+00
LT129         183         184      0.95753E-09
CT130         189           0      0.26987E-13
RT130         189           0      0.62873E+08
RT131         188         189      0.46160E-02
VT131         187         188 AC   0.00000E+00
LT131         186         187      0.95753E-09
CT132         192           0      0.26987E-13
RT132         192           0      0.62873E+08
RT133         191         192      0.46160E-02
VT133         190         191 AC   0.00000E+00
LT133         189         190      0.95753E-09
CT134         195           0      0.48472E-13
RT134         195           0      0.62873E+08
RT135         194         195      0.46160E-02
VT135         193         194 AC   0.00000E+00
LT135         192         193      0.95753E-09
CT136         196           0      0.48472E-13
RT136         196           0      0.62873E+08
CT137         199           0      0.26987E-13
RT137         199           0      0.62873E+08
RT138         198         199      0.46160E-02
VT138         197         198 AC   0.00000E+00
LT138         196         197      0.95753E-09
CT139         202           0      0.26987E-13
RT139         202           0      0.62873E+08
RT140         201         202      0.46160E-02
VT140         200         201 AC   0.00000E+00
LT140         199         200      0.95753E-09
CT141         205           0      0.26987E-13
RT141         205           0      0.62873E+08
RT142         204         205      0.46160E-02
VT142         203         204 AC   0.00000E+00
LT142         202         203      0.95753E-09
CT143         208           0      0.48472E-13
RT143         208           0      0.62873E+08
RT144         207         208      0.46160E-02
VT144         206         207 AC   0.00000E+00
LT144         205         206      0.95753E-09
CT145         209           0      0.48472E-13
RT145         209           0      0.62873E+08
CT146         212           0      0.26987E-13
RT146         212           0      0.62873E+08
RT147         211         212      0.46160E-02
VT147         210         211 AC   0.00000E+00
LT147         209         210      0.95753E-09
CT148         215           0      0.26987E-13
RT148         215           0      0.62873E+08
RT149         214         215      0.46160E-02
VT149         213         214 AC   0.00000E+00
LT149         212         213      0.95753E-09
CT150         218           0      0.26987E-13
RT150         218           0      0.62873E+08
RT151         217         218      0.46160E-02
VT151         216         217 AC   0.00000E+00
LT151         215         216      0.95753E-09
CT152         221           0      0.48472E-13
RT152         221           0      0.62873E+08
RT153         220         221      0.46160E-02
VT153         219         220 AC   0.00000E+00
LT153         218         219      0.95753E-09
CT154         222           0      0.48472E-13
RT154         222           0      0.62873E+08
CT155         225           0      0.26987E-13
RT155         225           0      0.62873E+08
RT156         224         225      0.46160E-02
VT156         223         224 AC   0.00000E+00
LT156         222         223      0.95753E-09
CT157         228           0      0.26987E-13
RT157         228           0      0.62873E+08
RT158         227         228      0.46160E-02
VT158         226         227 AC   0.00000E+00
LT158         225         226      0.95753E-09
CT159         231           0      0.26987E-13
RT159         231           0      0.62873E+08
RT160         230         231      0.46160E-02
VT160         229         230 AC   0.00000E+00
LT160         228         229      0.95753E-09
CT161         234           0      0.48472E-13
RT161         234           0      0.62873E+08
RT162         233         234      0.46160E-02
VT162         232         233 AC   0.00000E+00
LT162         231         232      0.95753E-09
CT163         235           0      0.48472E-13
RT163         235           0      0.62873E+08
CT164         238           0      0.26987E-13
RT164         238           0      0.62873E+08
RT165         237         238      0.46160E-02
VT165         236         237 AC   0.00000E+00
LT165         235         236      0.95753E-09
CT166         241           0      0.26987E-13
RT166         241           0      0.62873E+08
RT167         240         241      0.46160E-02
VT167         239         240 AC   0.00000E+00
LT167         238         239      0.95753E-09
CT168         244           0      0.26987E-13
RT168         244           0      0.62873E+08
RT169         243         244      0.46160E-02
VT169         242         243 AC   0.00000E+00
LT169         241         242      0.95753E-09
CT170         247           0      0.48472E-13
RT170         247           0      0.62873E+08
RT171         246         247      0.46160E-02
VT171         245         246 AC   0.00000E+00
LT171         244         245      0.95753E-09
CT172         248           0      0.48472E-13
RT172         248           0      0.62873E+08
CT173         251           0      0.26987E-13
RT173         251           0      0.62873E+08
RT174         250         251      0.46160E-02
VT174         249         250 AC   0.00000E+00
LT174         248         249      0.95753E-09
CT175         254           0      0.26987E-13
RT175         254           0      0.62873E+08
RT176         253         254      0.46160E-02
VT176         252         253 AC   0.00000E+00
LT176         251         252      0.95753E-09
CT177         257           0      0.26987E-13
RT177         257           0      0.62873E+08
RT178         256         257      0.46160E-02
VT178         255         256 AC   0.00000E+00
LT178         254         255      0.95753E-09
CT179         260           0      0.48472E-13
RT179         260           0      0.62873E+08
RT180         259         260      0.46160E-02
VT180         258         259 AC   0.00000E+00
LT180         257         258      0.95753E-09
CT181         261           0      0.48472E-13
RT181         261           0      0.62873E+08
CT182         264           0      0.26987E-13
RT182         264           0      0.62873E+08
RT183         263         264      0.46160E-02
VT183         262         263 AC   0.00000E+00
LT183         261         262      0.95753E-09
CT184         267           0      0.26987E-13
RT184         267           0      0.62873E+08
RT185         266         267      0.46160E-02
VT185         265         266 AC   0.00000E+00
LT185         264         265      0.95753E-09
CT186         270           0      0.26987E-13
RT186         270           0      0.62873E+08
RT187         269         270      0.46160E-02
VT187         268         269 AC   0.00000E+00
LT187         267         268      0.95753E-09
CT188         273           0      0.48472E-13
RT188         273           0      0.62873E+08
RT189         272         273      0.46160E-02
VT189         271         272 AC   0.00000E+00
LT189         270         271      0.95753E-09
CT190         274           0      0.48472E-13
RT190         274           0      0.62873E+08
CT191         277           0      0.26987E-13
RT191         277           0      0.62873E+08
RT192         276         277      0.46160E-02
VT192         275         276 AC   0.00000E+00
LT192         274         275      0.95753E-09
CT193         280           0      0.26987E-13
RT193         280           0      0.62873E+08
RT194         279         280      0.46160E-02
VT194         278         279 AC   0.00000E+00
LT194         277         278      0.95753E-09
CT195         283           0      0.26987E-13
RT195         283           0      0.62873E+08
RT196         282         283      0.46160E-02
VT196         281         282 AC   0.00000E+00
LT196         280         281      0.95753E-09
CT197         286           0      0.48472E-13
RT197         286           0      0.62873E+08
RT198         285         286      0.46160E-02
VT198         284         285 AC   0.00000E+00
LT198         283         284      0.95753E-09
CT199         287           0      0.48472E-13
RT199         287           0      0.62873E+08
CT200         290           0      0.26987E-13
RT200         290           0      0.62873E+08
RT201         289         290      0.46160E-02
VT201         288         289 AC   0.00000E+00
LT201         287         288      0.95753E-09
CT202         293           0      0.26987E-13
RT202         293           0      0.62873E+08
RT203         292         293      0.46160E-02
VT203         291         292 AC   0.00000E+00
LT203         290         291      0.95753E-09
CT204         296           0      0.26987E-13
RT204         296           0      0.62873E+08
RT205         295         296      0.46160E-02
VT205         294         295 AC   0.00000E+00
LT205         293         294      0.95753E-09
CT206         299           0      0.48472E-13
RT206         299           0      0.62873E+08
RT207         298         299      0.46160E-02
VT207         297         298 AC   0.00000E+00
LT207         296         297      0.95753E-09
CT208         300           0      0.48472E-13
RT208         300           0      0.62873E+08
CT209         303           0      0.26987E-13
RT209         303           0      0.62873E+08
RT210         302         303      0.46160E-02
VT210         301         302 AC   0.00000E+00
LT210         300         301      0.95753E-09
CT211         306           0      0.26987E-13
RT211         306           0      0.62873E+08
RT212         305         306      0.46160E-02
VT212         304         305 AC   0.00000E+00
LT212         303         304      0.95753E-09
CT213         309           0      0.26987E-13
RT213         309           0      0.62873E+08
RT214         308         309      0.46160E-02
VT214         307         308 AC   0.00000E+00
LT214         306         307      0.95753E-09
CT215         312           0      0.48472E-13
RT215         312           0      0.62873E+08
RT216         311         312      0.46160E-02
VT216         310         311 AC   0.00000E+00
LT216         309         310      0.95753E-09
CT217         313           0      0.48472E-13
RT217         313           0      0.62873E+08
CT218         316           0      0.26987E-13
RT218         316           0      0.62873E+08
RT219         315         316      0.46160E-02
VT219         314         315 AC   0.00000E+00
LT219         313         314      0.95753E-09
CT220         319           0      0.26987E-13
RT220         319           0      0.62873E+08
RT221         318         319      0.46160E-02
VT221         317         318 AC   0.00000E+00
LT221         316         317      0.95753E-09
CT222         322           0      0.26987E-13
RT222         322           0      0.62873E+08
RT223         321         322      0.46160E-02
VT223         320         321 AC   0.00000E+00
LT223         319         320      0.95753E-09
CT224         325           0      0.48472E-13
RT224         325           0      0.62873E+08
RT225         324         325      0.46160E-02
VT225         323         324 AC   0.00000E+00
LT225         322         323      0.95753E-09
CT226         326           0      0.48472E-13
RT226         326           0      0.62873E+08
CT227         329           0      0.26987E-13
RT227         329           0      0.62873E+08
RT228         328         329      0.46160E-02
VT228         327         328 AC   0.00000E+00
LT228         326         327      0.95753E-09
CT229         332           0      0.26987E-13
RT229         332           0      0.62873E+08
RT230         331         332      0.46160E-02
VT230         330         331 AC   0.00000E+00
LT230         329         330      0.95753E-09
CT231         335           0      0.26987E-13
RT231         335           0      0.62873E+08
RT232         334         335      0.46160E-02
VT232         333         334 AC   0.00000E+00
LT232         332         333      0.95753E-09
CT233         338           0      0.48472E-13
RT233         338           0      0.62873E+08
RT234         337         338      0.46160E-02
VT234         336         337 AC   0.00000E+00
LT234         335         336      0.95753E-09
CT235         339           0      0.48472E-13
RT235         339           0      0.62873E+08
CT236         342           0      0.26987E-13
RT236         342           0      0.62873E+08
RT237         341         342      0.46160E-02
VT237         340         341 AC   0.00000E+00
LT237         339         340      0.95753E-09
CT238         345           0      0.26987E-13
RT238         345           0      0.62873E+08
RT239         344         345      0.46160E-02
VT239         343         344 AC   0.00000E+00
LT239         342         343      0.95753E-09
CT240         348           0      0.26987E-13
RT240         348           0      0.62873E+08
RT241         347         348      0.46160E-02
VT241         346         347 AC   0.00000E+00
LT241         345         346      0.95753E-09
CT242         351           0      0.48472E-13
RT242         351           0      0.62873E+08
RT243         350         351      0.46160E-02
VT243         349         350 AC   0.00000E+00
LT243         348         349      0.95753E-09
CT244         352           0      0.48472E-13
RT244         352           0      0.62873E+08
CT245         355           0      0.26987E-13
RT245         355           0      0.62873E+08
RT246         354         355      0.46160E-02
VT246         353         354 AC   0.00000E+00
LT246         352         353      0.95753E-09
CT247         358           0      0.26987E-13
RT247         358           0      0.62873E+08
RT248         357         358      0.46160E-02
VT248         356         357 AC   0.00000E+00
LT248         355         356      0.95753E-09
CT249         361           0      0.26987E-13
RT249         361           0      0.62873E+08
RT250         360         361      0.46160E-02
VT250         359         360 AC   0.00000E+00
LT250         358         359      0.95753E-09
CT251         364           0      0.48472E-13
RT251         364           0      0.62873E+08
RT252         363         364      0.46160E-02
VT252         362         363 AC   0.00000E+00
LT252         361         362      0.95753E-09
CT253         365           0      0.48472E-13
RT253         365           0      0.62873E+08
CT254         368           0      0.26987E-13
RT254         368           0      0.62873E+08
RT255         367         368      0.46160E-02
VT255         366         367 AC   0.00000E+00
LT255         365         366      0.95753E-09
CT256         371           0      0.26987E-13
RT256         371           0      0.62873E+08
RT257         370         371      0.46160E-02
VT257         369         370 AC   0.00000E+00
LT257         368         369      0.95753E-09
CT258         374           0      0.26987E-13
RT258         374           0      0.62873E+08
RT259         373         374      0.46160E-02
VT259         372         373 AC   0.00000E+00
LT259         371         372      0.95753E-09
CT260         377           0      0.48472E-13
RT260         377           0      0.62873E+08
RT261         376         377      0.46160E-02
VT261         375         376 AC   0.00000E+00
LT261         374         375      0.95753E-09
CT262         378           0      0.48472E-13
RT262         378           0      0.62873E+08
CT263         381           0      0.26987E-13
RT263         381           0      0.62873E+08
RT264         380         381      0.46160E-02
VT264         379         380 AC   0.00000E+00
LT264         378         379      0.95753E-09
CT265         384           0      0.26987E-13
RT265         384           0      0.62873E+08
RT266         383         384      0.46160E-02
VT266         382         383 AC   0.00000E+00
LT266         381         382      0.95753E-09
CT267         387           0      0.26987E-13
RT267         387           0      0.62873E+08
RT268         386         387      0.46160E-02
VT268         385         386 AC   0.00000E+00
LT268         384         385      0.95753E-09
CT269         390           0      0.48472E-13
RT269         390           0      0.62873E+08
RT270         389         390      0.46160E-02
VT270         388         389 AC   0.00000E+00
LT270         387         388      0.95753E-09
CT271         391           0      0.48472E-13
RT271         391           0      0.62873E+08
CT272         394           0      0.26987E-13
RT272         394           0      0.62873E+08
RT273         393         394      0.46160E-02
VT273         392         393 AC   0.00000E+00
LT273         391         392      0.95753E-09
CT274         397           0      0.26987E-13
RT274         397           0      0.62873E+08
RT275         396         397      0.46160E-02
VT275         395         396 AC   0.00000E+00
LT275         394         395      0.95753E-09
CT276         400           0      0.26987E-13
RT276         400           0      0.62873E+08
RT277         399         400      0.46160E-02
VT277         398         399 AC   0.00000E+00
LT277         397         398      0.95753E-09
CT278         403           0      0.48472E-13
RT278         403           0      0.62873E+08
RT279         402         403      0.46160E-02
VT279         401         402 AC   0.00000E+00
LT279         400         401      0.95753E-09
CT280         404           0      0.48472E-13
RT280         404           0      0.62873E+08
CT281         407           0      0.26987E-13
RT281         407           0      0.62873E+08
RT282         406         407      0.46160E-02
VT282         405         406 AC   0.00000E+00
LT282         404         405      0.95753E-09
CT283         410           0      0.26987E-13
RT283         410           0      0.62873E+08
RT284         409         410      0.46160E-02
VT284         408         409 AC   0.00000E+00
LT284         407         408      0.95753E-09
CT285         413           0      0.26987E-13
RT285         413           0      0.62873E+08
RT286         412         413      0.46160E-02
VT286         411         412 AC   0.00000E+00
LT286         410         411      0.95753E-09
CT287         416           0      0.48472E-13
RT287         416           0      0.62873E+08
RT288         415         416      0.46160E-02
VT288         414         415 AC   0.00000E+00
LT288         413         414      0.95753E-09
CT289         417           0      0.48472E-13
RT289         417           0      0.62873E+08
CT290         420           0      0.26987E-13
RT290         420           0      0.62873E+08
RT291         419         420      0.46160E-02
VT291         418         419 AC   0.00000E+00
LT291         417         418      0.95753E-09
CT292         423           0      0.26987E-13
RT292         423           0      0.62873E+08
RT293         422         423      0.46160E-02
VT293         421         422 AC   0.00000E+00
LT293         420         421      0.95753E-09
CT294         426           0      0.26987E-13
RT294         426           0      0.62873E+08
RT295         425         426      0.46160E-02
VT295         424         425 AC   0.00000E+00
LT295         423         424      0.95753E-09
CT296         429           0      0.48472E-13
RT296         429           0      0.62873E+08
RT297         428         429      0.46160E-02
VT297         427         428 AC   0.00000E+00
LT297         426         427      0.95753E-09
CT298         430           0      0.48472E-13
RT298         430           0      0.62873E+08
CT299         433           0      0.26987E-13
RT299         433           0      0.62873E+08
RT300         432         433      0.46160E-02
VT300         431         432 AC   0.00000E+00
LT300         430         431      0.95753E-09
CT301         436           0      0.26987E-13
RT301         436           0      0.62873E+08
RT302         435         436      0.46160E-02
VT302         434         435 AC   0.00000E+00
LT302         433         434      0.95753E-09
CT303         439           0      0.26987E-13
RT303         439           0      0.62873E+08
RT304         438         439      0.46160E-02
VT304         437         438 AC   0.00000E+00
LT304         436         437      0.95753E-09
CT305         442           0      0.48472E-13
RT305         442           0      0.62873E+08
RT306         441         442      0.46160E-02
VT306         440         441 AC   0.00000E+00
LT306         439         440      0.95753E-09
CT307         443           0      0.48472E-13
RT307         443           0      0.62873E+08
CT308         446           0      0.26987E-13
RT308         446           0      0.62873E+08
RT309         445         446      0.46160E-02
VT309         444         445 AC   0.00000E+00
LT309         443         444      0.95753E-09
CT310         449           0      0.26987E-13
RT310         449           0      0.62873E+08
RT311         448         449      0.46160E-02
VT311         447         448 AC   0.00000E+00
LT311         446         447      0.95753E-09
CT312         452           0      0.26987E-13
RT312         452           0      0.62873E+08
RT313         451         452      0.46160E-02
VT313         450         451 AC   0.00000E+00
LT313         449         450      0.95753E-09
CT314         455           0      0.48472E-13
RT314         455           0      0.62873E+08
RT315         454         455      0.46160E-02
VT315         453         454 AC   0.00000E+00
LT315         452         453      0.95753E-09
CT316         456           0      0.48472E-13
RT316         456           0      0.62873E+08
CT317         459           0      0.26987E-13
RT317         459           0      0.62873E+08
RT318         458         459      0.46160E-02
VT318         457         458 AC   0.00000E+00
LT318         456         457      0.95753E-09
CT319         462           0      0.26987E-13
RT319         462           0      0.62873E+08
RT320         461         462      0.46160E-02
VT320         460         461 AC   0.00000E+00
LT320         459         460      0.95753E-09
CT321         465           0      0.26987E-13
RT321         465           0      0.62873E+08
RT322         464         465      0.46160E-02
VT322         463         464 AC   0.00000E+00
LT322         462         463      0.95753E-09
CT323         468           0      0.48472E-13
RT323         468           0      0.62873E+08
RT324         467         468      0.46160E-02
VT324         466         467 AC   0.00000E+00
LT324         465         466      0.95753E-09
CT325         469           0      0.48472E-13
RT325         469           0      0.62873E+08
CT326         472           0      0.26987E-13
RT326         472           0      0.62873E+08
RT327         471         472      0.46160E-02
VT327         470         471 AC   0.00000E+00
LT327         469         470      0.95753E-09
CT328         475           0      0.26987E-13
RT328         475           0      0.62873E+08
RT329         474         475      0.46160E-02
VT329         473         474 AC   0.00000E+00
LT329         472         473      0.95753E-09
CT330         478           0      0.26987E-13
RT330         478           0      0.62873E+08
RT331         477         478      0.46160E-02
VT331         476         477 AC   0.00000E+00
LT331         475         476      0.95753E-09
CT332         481           0      0.48472E-13
RT332         481           0      0.62873E+08
RT333         480         481      0.46160E-02
VT333         479         480 AC   0.00000E+00
LT333         478         479      0.95753E-09
CT334         482           0      0.48472E-13
RT334         482           0      0.62873E+08
CT335         485           0      0.26987E-13
RT335         485           0      0.62873E+08
RT336         484         485      0.46160E-02
VT336         483         484 AC   0.00000E+00
LT336         482         483      0.95753E-09
CT337         488           0      0.26987E-13
RT337         488           0      0.62873E+08
RT338         487         488      0.46160E-02
VT338         486         487 AC   0.00000E+00
LT338         485         486      0.95753E-09
CT339         491           0      0.26987E-13
RT339         491           0      0.62873E+08
RT340         490         491      0.46160E-02
VT340         489         490 AC   0.00000E+00
LT340         488         489      0.95753E-09
CT341         494           0      0.48472E-13
RT341         494           0      0.62873E+08
RT342         493         494      0.46160E-02
VT342         492         493 AC   0.00000E+00
LT342         491         492      0.95753E-09
CT343         495           0      0.48472E-13
RT343         495           0      0.62873E+08
CT344         498           0      0.26987E-13
RT344         498           0      0.62873E+08
RT345         497         498      0.46160E-02
VT345         496         497 AC   0.00000E+00
LT345         495         496      0.95753E-09
CT346         501           0      0.26987E-13
RT346         501           0      0.62873E+08
RT347         500         501      0.46160E-02
VT347         499         500 AC   0.00000E+00
LT347         498         499      0.95753E-09
CT348         504           0      0.26987E-13
RT348         504           0      0.62873E+08
RT349         503         504      0.46160E-02
VT349         502         503 AC   0.00000E+00
LT349         501         502      0.95753E-09
CT350         507           0      0.48472E-13
RT350         507           0      0.62873E+08
RT351         506         507      0.46160E-02
VT351         505         506 AC   0.00000E+00
LT351         504         505      0.95753E-09
CT352         508           0      0.48472E-13
RT352         508           0      0.62873E+08
CT353         511           0      0.26987E-13
RT353         511           0      0.62873E+08
RT354         510         511      0.46160E-02
VT354         509         510 AC   0.00000E+00
LT354         508         509      0.95753E-09
CT355         514           0      0.26987E-13
RT355         514           0      0.62873E+08
RT356         513         514      0.46160E-02
VT356         512         513 AC   0.00000E+00
LT356         511         512      0.95753E-09
CT357         517           0      0.26987E-13
RT357         517           0      0.62873E+08
RT358         516         517      0.46160E-02
VT358         515         516 AC   0.00000E+00
LT358         514         515      0.95753E-09
CT359         520           0      0.48472E-13
RT359         520           0      0.62873E+08
RT360         519         520      0.46160E-02
VT360         518         519 AC   0.00000E+00
LT360         517         518      0.95753E-09
CT361         521           0      0.48472E-13
RT361         521           0      0.62873E+08
CT362         524           0      0.26987E-13
RT362         524           0      0.62873E+08
RT363         523         524      0.46160E-02
VT363         522         523 AC   0.00000E+00
LT363         521         522      0.95753E-09
CT364         527           0      0.26987E-13
RT364         527           0      0.62873E+08
RT365         526         527      0.46160E-02
VT365         525         526 AC   0.00000E+00
LT365         524         525      0.95753E-09
CT366         530           0      0.26987E-13
RT366         530           0      0.62873E+08
RT367         529         530      0.46160E-02
VT367         528         529 AC   0.00000E+00
LT367         527         528      0.95753E-09
CT368         533           0      0.48472E-13
RT368         533           0      0.62873E+08
RT369         532         533      0.46160E-02
VT369         531         532 AC   0.00000E+00
LT369         530         531      0.95753E-09
CT370         534           0      0.48472E-13
RT370         534           0      0.62873E+08
CT371         537           0      0.26987E-13
RT371         537           0      0.62873E+08
RT372         536         537      0.46160E-02
VT372         535         536 AC   0.00000E+00
LT372         534         535      0.95753E-09
CT373         540           0      0.26987E-13
RT373         540           0      0.62873E+08
RT374         539         540      0.46160E-02
VT374         538         539 AC   0.00000E+00
LT374         537         538      0.95753E-09
CT375         543           0      0.26987E-13
RT375         543           0      0.62873E+08
RT376         542         543      0.46160E-02
VT376         541         542 AC   0.00000E+00
LT376         540         541      0.95753E-09
CT377         546           0      0.48472E-13
RT377         546           0      0.62873E+08
RT378         545         546      0.46160E-02
VT378         544         545 AC   0.00000E+00
LT378         543         544      0.95753E-09
CT379         547           0      0.48472E-13
RT379         547           0      0.62873E+08
CT380         550           0      0.26987E-13
RT380         550           0      0.62873E+08
RT381         549         550      0.46160E-02
VT381         548         549 AC   0.00000E+00
LT381         547         548      0.95753E-09
CT382         553           0      0.26987E-13
RT382         553           0      0.62873E+08
RT383         552         553      0.46160E-02
VT383         551         552 AC   0.00000E+00
LT383         550         551      0.95753E-09
CT384         556           0      0.26987E-13
RT384         556           0      0.62873E+08
RT385         555         556      0.46160E-02
VT385         554         555 AC   0.00000E+00
LT385         553         554      0.95753E-09
CT386         559           0      0.48472E-13
RT386         559           0      0.62873E+08
RT387         558         559      0.46160E-02
VT387         557         558 AC   0.00000E+00
LT387         556         557      0.95753E-09
CT388         560           0      0.48472E-13
RT388         560           0      0.62873E+08
CT389         563           0      0.26987E-13
RT389         563           0      0.62873E+08
RT390         562         563      0.46160E-02
VT390         561         562 AC   0.00000E+00
LT390         560         561      0.95753E-09
CT391         566           0      0.26987E-13
RT391         566           0      0.62873E+08
RT392         565         566      0.46160E-02
VT392         564         565 AC   0.00000E+00
LT392         563         564      0.95753E-09
CT393         569           0      0.26987E-13
RT393         569           0      0.62873E+08
RT394         568         569      0.46160E-02
VT394         567         568 AC   0.00000E+00
LT394         566         567      0.95753E-09
CT395         572           0      0.48472E-13
RT395         572           0      0.62873E+08
RT396         571         572      0.46160E-02
VT396         570         571 AC   0.00000E+00
LT396         569         570      0.95753E-09
CT397         573           0      0.48472E-13
RT397         573           0      0.62873E+08
CT398         576           0      0.26987E-13
RT398         576           0      0.62873E+08
RT399         575         576      0.46160E-02
VT399         574         575 AC   0.00000E+00
LT399         573         574      0.95753E-09
CT400         579           0      0.26987E-13
RT400         579           0      0.62873E+08
RT401         578         579      0.46160E-02
VT401         577         578 AC   0.00000E+00
LT401         576         577      0.95753E-09
CT402         582           0      0.26987E-13
RT402         582           0      0.62873E+08
RT403         581         582      0.46160E-02
VT403         580         581 AC   0.00000E+00
LT403         579         580      0.95753E-09
CT404         585           0      0.48472E-13
RT404         585           0      0.62873E+08
RT405         584         585      0.46160E-02
VT405         583         584 AC   0.00000E+00
LT405         582         583      0.95753E-09
CT406         586           0      0.48472E-13
RT406         586           0      0.62873E+08
CT407         589           0      0.26987E-13
RT407         589           0      0.62873E+08
RT408         588         589      0.46160E-02
VT408         587         588 AC   0.00000E+00
LT408         586         587      0.95753E-09
CT409         592           0      0.26987E-13
RT409         592           0      0.62873E+08
RT410         591         592      0.46160E-02
VT410         590         591 AC   0.00000E+00
LT410         589         590      0.95753E-09
CT411         595           0      0.26987E-13
RT411         595           0      0.62873E+08
RT412         594         595      0.46160E-02
VT412         593         594 AC   0.00000E+00
LT412         592         593      0.95753E-09
CT413         598           0      0.48472E-13
RT413         598           0      0.62873E+08
RT414         597         598      0.46160E-02
VT414         596         597 AC   0.00000E+00
LT414         595         596      0.95753E-09
CT415         599           0      0.48472E-13
RT415         599           0      0.62873E+08
CT416         602           0      0.26987E-13
RT416         602           0      0.62873E+08
RT417         601         602      0.46160E-02
VT417         600         601 AC   0.00000E+00
LT417         599         600      0.95753E-09
CT418         605           0      0.26987E-13
RT418         605           0      0.62873E+08
RT419         604         605      0.46160E-02
VT419         603         604 AC   0.00000E+00
LT419         602         603      0.95753E-09
CT420         608           0      0.26987E-13
RT420         608           0      0.62873E+08
RT421         607         608      0.46160E-02
VT421         606         607 AC   0.00000E+00
LT421         605         606      0.95753E-09
CT422         611           0      0.48472E-13
RT422         611           0      0.62873E+08
RT423         610         611      0.46160E-02
VT423         609         610 AC   0.00000E+00
LT423         608         609      0.95753E-09
CT424         612           0      0.48472E-13
RT424         612           0      0.62873E+08
CT425         615           0      0.26987E-13
RT425         615           0      0.62873E+08
RT426         614         615      0.46160E-02
VT426         613         614 AC   0.00000E+00
LT426         612         613      0.95753E-09
CT427         618           0      0.26987E-13
RT427         618           0      0.62873E+08
RT428         617         618      0.46160E-02
VT428         616         617 AC   0.00000E+00
LT428         615         616      0.95753E-09
CT429         621           0      0.26987E-13
RT429         621           0      0.62873E+08
RT430         620         621      0.46160E-02
VT430         619         620 AC   0.00000E+00
LT430         618         619      0.95753E-09
CT431         624           0      0.48472E-13
RT431         624           0      0.62873E+08
RT432         623         624      0.46160E-02
VT432         622         623 AC   0.00000E+00
LT432         621         622      0.95753E-09
CT433         625           0      0.48472E-13
RT433         625           0      0.62873E+08
CT434         628           0      0.26987E-13
RT434         628           0      0.62873E+08
RT435         627         628      0.46160E-02
VT435         626         627 AC   0.00000E+00
LT435         625         626      0.95753E-09
CT436         631           0      0.26987E-13
RT436         631           0      0.62873E+08
RT437         630         631      0.46160E-02
VT437         629         630 AC   0.00000E+00
LT437         628         629      0.95753E-09
CT438         634           0      0.26987E-13
RT438         634           0      0.62873E+08
RT439         633         634      0.46160E-02
VT439         632         633 AC   0.00000E+00
LT439         631         632      0.95753E-09
CT440         637           0      0.48472E-13
RT440         637           0      0.62873E+08
RT441         636         637      0.46160E-02
VT441         635         636 AC   0.00000E+00
LT441         634         635      0.95753E-09
CT442         638           0      0.48472E-13
RT442         638           0      0.62873E+08
CT443         641           0      0.26987E-13
RT443         641           0      0.62873E+08
RT444         640         641      0.46160E-02
VT444         639         640 AC   0.00000E+00
LT444         638         639      0.95753E-09
CT445         644           0      0.26987E-13
RT445         644           0      0.62873E+08
RT446         643         644      0.46160E-02
VT446         642         643 AC   0.00000E+00
LT446         641         642      0.95753E-09
CT447         647           0      0.26987E-13
RT447         647           0      0.62873E+08
RT448         646         647      0.46160E-02
VT448         645         646 AC   0.00000E+00
LT448         644         645      0.95753E-09
CT449         650           0      0.48472E-13
RT449         650           0      0.62873E+08
RT450         649         650      0.46160E-02
VT450         648         649 AC   0.00000E+00
LT450         647         648      0.95753E-09
CT451         651           0      0.48472E-13
RT451         651           0      0.62873E+08
CT452         654           0      0.26987E-13
RT452         654           0      0.62873E+08
RT453         653         654      0.46160E-02
VT453         652         653 AC   0.00000E+00
LT453         651         652      0.95753E-09
CT454         657           0      0.26987E-13
RT454         657           0      0.62873E+08
RT455         656         657      0.46160E-02
VT455         655         656 AC   0.00000E+00
LT455         654         655      0.95753E-09
CT456         660           0      0.26987E-13
RT456         660           0      0.62873E+08
RT457         659         660      0.46160E-02
VT457         658         659 AC   0.00000E+00
LT457         657         658      0.95753E-09
CT458         663           0      0.48472E-13
RT458         663           0      0.62873E+08
RT459         662         663      0.46160E-02
VT459         661         662 AC   0.00000E+00
LT459         660         661      0.95753E-09
CT460         664           0      0.48472E-13
RT460         664           0      0.62873E+08
CT461         667           0      0.26987E-13
RT461         667           0      0.62873E+08
RT462         666         667      0.46160E-02
VT462         665         666 AC   0.00000E+00
LT462         664         665      0.95753E-09
CT463         670           0      0.26987E-13
RT463         670           0      0.62873E+08
RT464         669         670      0.46160E-02
VT464         668         669 AC   0.00000E+00
LT464         667         668      0.95753E-09
CT465         673           0      0.26987E-13
RT465         673           0      0.62873E+08
RT466         672         673      0.46160E-02
VT466         671         672 AC   0.00000E+00
LT466         670         671      0.95753E-09
CT467         676           0      0.48472E-13
RT467         676           0      0.62873E+08
RT468         675         676      0.46160E-02
VT468         674         675 AC   0.00000E+00
LT468         673         674      0.95753E-09
CT469         677           0      0.48472E-13
RT469         677           0      0.62873E+08
CT470         680           0      0.26987E-13
RT470         680           0      0.62873E+08
RT471         679         680      0.46160E-02
VT471         678         679 AC   0.00000E+00
LT471         677         678      0.95753E-09
CT472         683           0      0.26987E-13
RT472         683           0      0.62873E+08
RT473         682         683      0.46160E-02
VT473         681         682 AC   0.00000E+00
LT473         680         681      0.95753E-09
CT474         686           0      0.26987E-13
RT474         686           0      0.62873E+08
RT475         685         686      0.46160E-02
VT475         684         685 AC   0.00000E+00
LT475         683         684      0.95753E-09
CT476         689           0      0.48472E-13
RT476         689           0      0.62873E+08
RT477         688         689      0.46160E-02
VT477         687         688 AC   0.00000E+00
LT477         686         687      0.95753E-09
CT478         690           0      0.48472E-13
RT478         690           0      0.62873E+08
CT479         693           0      0.26987E-13
RT479         693           0      0.62873E+08
RT480         692         693      0.46160E-02
VT480         691         692 AC   0.00000E+00
LT480         690         691      0.95753E-09
CT481         696           0      0.26987E-13
RT481         696           0      0.62873E+08
RT482         695         696      0.46160E-02
VT482         694         695 AC   0.00000E+00
LT482         693         694      0.95753E-09
CT483         699           0      0.26987E-13
RT483         699           0      0.62873E+08
RT484         698         699      0.46160E-02
VT484         697         698 AC   0.00000E+00
LT484         696         697      0.95753E-09
CT485         702           0      0.48472E-13
RT485         702           0      0.62873E+08
RT486         701         702      0.46160E-02
VT486         700         701 AC   0.00000E+00
LT486         699         700      0.95753E-09
CT487         703           0      0.48472E-13
RT487         703           0      0.62873E+08
CT488         706           0      0.26987E-13
RT488         706           0      0.62873E+08
RT489         705         706      0.46160E-02
VT489         704         705 AC   0.00000E+00
LT489         703         704      0.95753E-09
CT490         709           0      0.26987E-13
RT490         709           0      0.62873E+08
RT491         708         709      0.46160E-02
VT491         707         708 AC   0.00000E+00
LT491         706         707      0.95753E-09
CT492         712           0      0.26987E-13
RT492         712           0      0.62873E+08
RT493         711         712      0.46160E-02
VT493         710         711 AC   0.00000E+00
LT493         709         710      0.95753E-09
CT494         715           0      0.48472E-13
RT494         715           0      0.62873E+08
RT495         714         715      0.46160E-02
VT495         713         714 AC   0.00000E+00
LT495         712         713      0.95753E-09
CT496         716           0      0.48472E-13
RT496         716           0      0.62873E+08
CT497         719           0      0.26987E-13
RT497         719           0      0.62873E+08
RT498         718         719      0.46160E-02
VT498         717         718 AC   0.00000E+00
LT498         716         717      0.95753E-09
CT499         722           0      0.26987E-13
RT499         722           0      0.62873E+08
RT500         721         722      0.46160E-02
VT500         720         721 AC   0.00000E+00
LT500         719         720      0.95753E-09
CT501         725           0      0.26987E-13
RT501         725           0      0.62873E+08
RT502         724         725      0.46160E-02
VT502         723         724 AC   0.00000E+00
LT502         722         723      0.95753E-09
CT503         728           0      0.48472E-13
RT503         728           0      0.62873E+08
RT504         727         728      0.46160E-02
VT504         726         727 AC   0.00000E+00
LT504         725         726      0.95753E-09
CT505         729           0      0.48472E-13
RT505         729           0      0.62873E+08
CT506         732           0      0.26987E-13
RT506         732           0      0.62873E+08
RT507         731         732      0.46160E-02
VT507         730         731 AC   0.00000E+00
LT507         729         730      0.95753E-09
CT508         735           0      0.26987E-13
RT508         735           0      0.62873E+08
RT509         734         735      0.46160E-02
VT509         733         734 AC   0.00000E+00
LT509         732         733      0.95753E-09
CT510         738           0      0.26987E-13
RT510         738           0      0.62873E+08
RT511         737         738      0.46160E-02
VT511         736         737 AC   0.00000E+00
LT511         735         736      0.95753E-09
CT512         741           0      0.48472E-13
RT512         741           0      0.62873E+08
RT513         740         741      0.46160E-02
VT513         739         740 AC   0.00000E+00
LT513         738         739      0.95753E-09
CT514         742           0      0.56354E-13
RT514         742           0      0.62873E+08
CT515         745           0      0.26987E-13
RT515         745           0      0.62873E+08
RT516         744         745      0.46160E-02
VT516         743         744 AC   0.00000E+00
LT516         742         743      0.95753E-09
CT517         748           0      0.26987E-13
RT517         748           0      0.62873E+08
RT518         747         748      0.46160E-02
VT518         746         747 AC   0.00000E+00
LT518         745         746      0.95753E-09
CT519         751           0      0.26987E-13
RT519         751           0      0.62873E+08
RT520         750         751      0.46160E-02
VT520         749         750 AC   0.00000E+00
LT520         748         749      0.95753E-09
CT521         754           0      0.26987E-13
RT521         754           0      0.62873E+08
RT522         753         754      0.46160E-02
VT522         752         753 AC   0.00000E+00
LT522         751         752      0.95753E-09
CT523         757           0      0.48472E-13
RT523         757           0      0.62873E+08
RT524         756         757      0.46160E-02
VT524         755         756 AC   0.00000E+00
LT524         754         755      0.64812E-09
CT525         760           0      0.48472E-13
RT525         760           0      0.62873E+08
RT526         759         760      0.46160E-02
VT526         758         759 AC   0.00000E+00
LT526         757         758      0.33871E-09
CT527         763           0      0.48472E-13
RT527         763           0      0.62873E+08
RT528         762         763      0.46160E-02
VT528         761         762 AC   0.00000E+00
LT528         760         761      0.33871E-09
CT529         766           0      0.48472E-13
RT529         766           0      0.62873E+08
RT530         765         766      0.46160E-02
VT530         764         765 AC   0.00000E+00
LT530         763         764      0.33871E-09
CT531         769           0      0.48472E-13
RT531         769           0      0.62873E+08
RT532         768         769      0.46160E-02
VT532         767         768 AC   0.00000E+00
LT532         766         767      0.33871E-09
CT533         772           0      0.48472E-13
RT533         772           0      0.62873E+08
RT534         771         772      0.46160E-02
VT534         770         771 AC   0.00000E+00
LT534         769         770      0.33871E-09
CT535         775           0      0.48472E-13
RT535         775           0      0.62873E+08
RT536         774         775      0.46160E-02
VT536         773         774 AC   0.00000E+00
LT536         772         773      0.33871E-09
CT537         778           0      0.48472E-13
RT537         778           0      0.62873E+08
RT538         777         778      0.46160E-02
VT538         776         777 AC   0.00000E+00
LT538         775         776      0.33871E-09
CT539         781           0      0.48472E-13
RT539         781           0      0.62873E+08
RT540         780         781      0.46160E-02
VT540         779         780 AC   0.00000E+00
LT540         778         779      0.33871E-09
CT541         784           0      0.48472E-13
RT541         784           0      0.62873E+08
RT542         783         784      0.46160E-02
VT542         782         783 AC   0.00000E+00
LT542         781         782      0.33871E-09
CT543         787           0      0.48472E-13
RT543         787           0      0.62873E+08
RT544         786         787      0.46160E-02
VT544         785         786 AC   0.00000E+00
LT544         784         785      0.33871E-09
CT545         790           0      0.48472E-13
RT545         790           0      0.62873E+08
RT546         789         790      0.46160E-02
VT546         788         789 AC   0.00000E+00
LT546         787         788      0.33871E-09
CT547         793           0      0.48472E-13
RT547         793           0      0.62873E+08
RT548         792         793      0.46160E-02
VT548         791         792 AC   0.00000E+00
LT548         790         791      0.33871E-09
CT549         796           0      0.48472E-13
RT549         796           0      0.62873E+08
RT550         795         796      0.46160E-02
VT550         794         795 AC   0.00000E+00
LT550         793         794      0.33871E-09
CT551         799           0      0.48472E-13
RT551         799           0      0.62873E+08
RT552         798         799      0.46160E-02
VT552         797         798 AC   0.00000E+00
LT552         796         797      0.33871E-09
CT553         802           0      0.48472E-13
RT553         802           0      0.62873E+08
RT554         801         802      0.46160E-02
VT554         800         801 AC   0.00000E+00
LT554         799         800      0.33871E-09
CT555         805           0      0.48472E-13
RT555         805           0      0.62873E+08
RT556         804         805      0.46160E-02
VT556         803         804 AC   0.00000E+00
LT556         802         803      0.33871E-09
CT557         808           0      0.48472E-13
RT557         808           0      0.62873E+08
RT558         807         808      0.46160E-02
VT558         806         807 AC   0.00000E+00
LT558         805         806      0.33871E-09
CT559         811           0      0.48472E-13
RT559         811           0      0.62873E+08
RT560         810         811      0.46160E-02
VT560         809         810 AC   0.00000E+00
LT560         808         809      0.33871E-09
CT561         814           0      0.48472E-13
RT561         814           0      0.62873E+08
RT562         813         814      0.46160E-02
VT562         812         813 AC   0.00000E+00
LT562         811         812      0.33871E-09
CT563         817           0      0.48472E-13
RT563         817           0      0.62873E+08
RT564         816         817      0.46160E-02
VT564         815         816 AC   0.00000E+00
LT564         814         815      0.33871E-09
CT565         820           0      0.48472E-13
RT565         820           0      0.62873E+08
RT566         819         820      0.46160E-02
VT566         818         819 AC   0.00000E+00
LT566         817         818      0.33871E-09
CT567         823           0      0.48472E-13
RT567         823           0      0.62873E+08
RT568         822         823      0.46160E-02
VT568         821         822 AC   0.00000E+00
LT568         820         821      0.33871E-09
CT569         826           0      0.48472E-13
RT569         826           0      0.62873E+08
RT570         825         826      0.46160E-02
VT570         824         825 AC   0.00000E+00
LT570         823         824      0.33871E-09
CT571         829           0      0.48472E-13
RT571         829           0      0.62873E+08
RT572         828         829      0.46160E-02
VT572         827         828 AC   0.00000E+00
LT572         826         827      0.33871E-09
CT573         832           0      0.48472E-13
RT573         832           0      0.62873E+08
RT574         831         832      0.46160E-02
VT574         830         831 AC   0.00000E+00
LT574         829         830      0.33871E-09
CT575         835           0      0.48472E-13
RT575         835           0      0.62873E+08
RT576         834         835      0.46160E-02
VT576         833         834 AC   0.00000E+00
LT576         832         833      0.33871E-09
CT577         838           0      0.48472E-13
RT577         838           0      0.62873E+08
RT578         837         838      0.46160E-02
VT578         836         837 AC   0.00000E+00
LT578         835         836      0.33871E-09
CT579         841           0      0.48472E-13
RT579         841           0      0.62873E+08
RT580         840         841      0.46160E-02
VT580         839         840 AC   0.00000E+00
LT580         838         839      0.33871E-09
CT581         844           0      0.48472E-13
RT581         844           0      0.62873E+08
RT582         843         844      0.46160E-02
VT582         842         843 AC   0.00000E+00
LT582         841         842      0.33871E-09
CT583         847           0      0.48472E-13
RT583         847           0      0.62873E+08
RT584         846         847      0.46160E-02
VT584         845         846 AC   0.00000E+00
LT584         844         845      0.33871E-09
CT585         850           0      0.48472E-13
RT585         850           0      0.62873E+08
RT586         849         850      0.46160E-02
VT586         848         849 AC   0.00000E+00
LT586         847         848      0.33871E-09
CT587         853           0      0.48472E-13
RT587         853           0      0.62873E+08
RT588         852         853      0.46160E-02
VT588         851         852 AC   0.00000E+00
LT588         850         851      0.33871E-09
CT589         856           0      0.48472E-13
RT589         856           0      0.62873E+08
RT590         855         856      0.46160E-02
VT590         854         855 AC   0.00000E+00
LT590         853         854      0.33871E-09
CT591         859           0      0.48472E-13
RT591         859           0      0.62873E+08
RT592         858         859      0.46160E-02
VT592         857         858 AC   0.00000E+00
LT592         856         857      0.33871E-09
CT593         862           0      0.48472E-13
RT593         862           0      0.62873E+08
RT594         861         862      0.46160E-02
VT594         860         861 AC   0.00000E+00
LT594         859         860      0.33871E-09
CT595         865           0      0.48472E-13
RT595         865           0      0.62873E+08
RT596         864         865      0.46160E-02
VT596         863         864 AC   0.00000E+00
LT596         862         863      0.33871E-09
CT597         868           0      0.48472E-13
RT597         868           0      0.62873E+08
RT598         867         868      0.46160E-02
VT598         866         867 AC   0.00000E+00
LT598         865         866      0.33871E-09
CT599         871           0      0.48472E-13
RT599         871           0      0.62873E+08
RT600         870         871      0.46160E-02
VT600         869         870 AC   0.00000E+00
LT600         868         869      0.33871E-09
CT601         874           0      0.48472E-13
RT601         874           0      0.62873E+08
RT602         873         874      0.46160E-02
VT602         872         873 AC   0.00000E+00
LT602         871         872      0.33871E-09
CT603         877           0      0.48472E-13
RT603         877           0      0.62873E+08
RT604         876         877      0.46160E-02
VT604         875         876 AC   0.00000E+00
LT604         874         875      0.33871E-09
CT605         880           0      0.48472E-13
RT605         880           0      0.62873E+08
RT606         879         880      0.46160E-02
VT606         878         879 AC   0.00000E+00
LT606         877         878      0.33871E-09
CT607         883           0      0.48472E-13
RT607         883           0      0.62873E+08
RT608         882         883      0.46160E-02
VT608         881         882 AC   0.00000E+00
LT608         880         881      0.33871E-09
CT609         886           0      0.48472E-13
RT609         886           0      0.62873E+08
RT610         885         886      0.46160E-02
VT610         884         885 AC   0.00000E+00
LT610         883         884      0.33871E-09
CT611         889           0      0.48472E-13
RT611         889           0      0.62873E+08
RT612         888         889      0.46160E-02
VT612         887         888 AC   0.00000E+00
LT612         886         887      0.33871E-09
CT613         892           0      0.48472E-13
RT613         892           0      0.62873E+08
RT614         891         892      0.46160E-02
VT614         890         891 AC   0.00000E+00
LT614         889         890      0.33871E-09
CT615         895           0      0.48472E-13
RT615         895           0      0.62873E+08
RT616         894         895      0.46160E-02
VT616         893         894 AC   0.00000E+00
LT616         892         893      0.33871E-09
CT617         898           0      0.48472E-13
RT617         898           0      0.62873E+08
RT618         897         898      0.46160E-02
VT618         896         897 AC   0.00000E+00
LT618         895         896      0.33871E-09
CT619         901           0      0.48472E-13
RT619         901           0      0.62873E+08
RT620         900         901      0.46160E-02
VT620         899         900 AC   0.00000E+00
LT620         898         899      0.33871E-09
CT621         904           0      0.48472E-13
RT621         904           0      0.62873E+08
RT622         903         904      0.46160E-02
VT622         902         903 AC   0.00000E+00
LT622         901         902      0.33871E-09
CT623         907           0      0.48472E-13
RT623         907           0      0.62873E+08
RT624         906         907      0.46160E-02
VT624         905         906 AC   0.00000E+00
LT624         904         905      0.33871E-09
CT625         910           0      0.48472E-13
RT625         910           0      0.62873E+08
RT626         909         910      0.46160E-02
VT626         908         909 AC   0.00000E+00
LT626         907         908      0.33871E-09
CT627         913           0      0.48472E-13
RT627         913           0      0.62873E+08
RT628         912         913      0.46160E-02
VT628         911         912 AC   0.00000E+00
LT628         910         911      0.33871E-09
CT629         916           0      0.48472E-13
RT629         916           0      0.62873E+08
RT630         915         916      0.46160E-02
VT630         914         915 AC   0.00000E+00
LT630         913         914      0.33871E-09
CT631         919           0      0.48472E-13
RT631         919           0      0.62873E+08
RT632         918         919      0.46160E-02
VT632         917         918 AC   0.00000E+00
LT632         916         917      0.33871E-09
CT633         922           0      0.48472E-13
RT633         922           0      0.62873E+08
RT634         921         922      0.46160E-02
VT634         920         921 AC   0.00000E+00
LT634         919         920      0.33871E-09
CT635         925           0      0.48472E-13
RT635         925           0      0.62873E+08
RT636         924         925      0.46160E-02
VT636         923         924 AC   0.00000E+00
LT636         922         923      0.33871E-09
CT637         928           0      0.48472E-13
RT637         928           0      0.62873E+08
RT638         927         928      0.46160E-02
VT638         926         927 AC   0.00000E+00
LT638         925         926      0.33871E-09
CT639         931           0      0.48472E-13
RT639         931           0      0.62873E+08
RT640         930         931      0.46160E-02
VT640         929         930 AC   0.00000E+00
LT640         928         929      0.33871E-09
CT641         934           0      0.77839E-13
RT641         934           0      0.62873E+08
RT642         933         934      0.46160E-02
VT642         932         933 AC   0.00000E+00
LT642         931         932      0.33871E-09
CT643         935           0      0.56354E-13
RT643         935           0      0.62873E+08
CT644         938           0      0.26987E-13
RT644         938           0      0.62873E+08
RT645         937         938      0.46160E-02
VT645         936         937 AC   0.00000E+00
LT645         935         936      0.95753E-09
CT646         941           0      0.26987E-13
RT646         941           0      0.62873E+08
RT647         940         941      0.46160E-02
VT647         939         940 AC   0.00000E+00
LT647         938         939      0.95753E-09
CT648         944           0      0.26987E-13
RT648         944           0      0.62873E+08
RT649         943         944      0.46160E-02
VT649         942         943 AC   0.00000E+00
LT649         941         942      0.95753E-09
CT650         947           0      0.26987E-13
RT650         947           0      0.62873E+08
RT651         946         947      0.46160E-02
VT651         945         946 AC   0.00000E+00
LT651         944         945      0.95753E-09
CT652         950           0      0.26987E-13
RT652         950           0      0.62873E+08
RT653         949         950      0.46160E-02
VT653         948         949 AC   0.00000E+00
LT653         947         948      0.95753E-09
CT654         953           0      0.26987E-13
RT654         953           0      0.62873E+08
RT655         952         953      0.46160E-02
VT655         951         952 AC   0.00000E+00
LT655         950         951      0.95753E-09
CT656         956           0      0.26987E-13
RT656         956           0      0.62873E+08
RT657         955         956      0.46160E-02
VT657         954         955 AC   0.00000E+00
LT657         953         954      0.95753E-09
CT658         959           0      0.26987E-13
RT658         959           0      0.62873E+08
RT659         958         959      0.46160E-02
VT659         957         958 AC   0.00000E+00
LT659         956         957      0.95753E-09
CT660         962           0      0.26987E-13
RT660         962           0      0.62873E+08
RT661         961         962      0.46160E-02
VT661         960         961 AC   0.00000E+00
LT661         959         960      0.95753E-09
CT662         965           0      0.26987E-13
RT662         965           0      0.62873E+08
RT663         964         965      0.46160E-02
VT663         963         964 AC   0.00000E+00
LT663         962         963      0.95753E-09
CT664         968           0      0.26987E-13
RT664         968           0      0.62873E+08
RT665         967         968      0.46160E-02
VT665         966         967 AC   0.00000E+00
LT665         965         966      0.95753E-09
CT666         971           0      0.26987E-13
RT666         971           0      0.62873E+08
RT667         970         971      0.46160E-02
VT667         969         970 AC   0.00000E+00
LT667         968         969      0.95753E-09
CT668         974           0      0.26987E-13
RT668         974           0      0.62873E+08
RT669         973         974      0.46160E-02
VT669         972         973 AC   0.00000E+00
LT669         971         972      0.95753E-09
CT670         977           0      0.26987E-13
RT670         977           0      0.62873E+08
RT671         976         977      0.46160E-02
VT671         975         976 AC   0.00000E+00
LT671         974         975      0.95753E-09
CT672         980           0      0.26987E-13
RT672         980           0      0.62873E+08
RT673         979         980      0.46160E-02
VT673         978         979 AC   0.00000E+00
LT673         977         978      0.95753E-09
CT674         983           0      0.26987E-13
RT674         983           0      0.62873E+08
RT675         982         983      0.46160E-02
VT675         981         982 AC   0.00000E+00
LT675         980         981      0.95753E-09
CT676         986           0      0.26987E-13
RT676         986           0      0.62873E+08
RT677         985         986      0.46160E-02
VT677         984         985 AC   0.00000E+00
LT677         983         984      0.95753E-09
CT678         989           0      0.26987E-13
RT678         989           0      0.62873E+08
RT679         988         989      0.46160E-02
VT679         987         988 AC   0.00000E+00
LT679         986         987      0.95753E-09
CT680         992           0      0.26987E-13
RT680         992           0      0.62873E+08
RT681         991         992      0.46160E-02
VT681         990         991 AC   0.00000E+00
LT681         989         990      0.95753E-09
CT682         995           0      0.26987E-13
RT682         995           0      0.62873E+08
RT683         994         995      0.46160E-02
VT683         993         994 AC   0.00000E+00
LT683         992         993      0.95753E-09
CT684         998           0      0.26987E-13
RT684         998           0      0.62873E+08
RT685         997         998      0.46160E-02
VT685         996         997 AC   0.00000E+00
LT685         995         996      0.95753E-09
CT686        1001           0      0.26987E-13
RT686        1001           0      0.62873E+08
RT687        1000        1001      0.46160E-02
VT687         999        1000 AC   0.00000E+00
LT687         998         999      0.95753E-09
CT688        1004           0      0.26987E-13
RT688        1004           0      0.62873E+08
RT689        1003        1004      0.46160E-02
VT689        1002        1003 AC   0.00000E+00
LT689        1001        1002      0.95753E-09
CT690        1007           0      0.26987E-13
RT690        1007           0      0.62873E+08
RT691        1006        1007      0.46160E-02
VT691        1005        1006 AC   0.00000E+00
LT691        1004        1005      0.95753E-09
CT692        1010           0      0.26987E-13
RT692        1010           0      0.62873E+08
RT693        1009        1010      0.46160E-02
VT693        1008        1009 AC   0.00000E+00
LT693        1007        1008      0.95753E-09
CT694        1013           0      0.26987E-13
RT694        1013           0      0.62873E+08
RT695        1012        1013      0.46160E-02
VT695        1011        1012 AC   0.00000E+00
LT695        1010        1011      0.95753E-09
CT696        1016           0      0.26987E-13
RT696        1016           0      0.62873E+08
RT697        1015        1016      0.46160E-02
VT697        1014        1015 AC   0.00000E+00
LT697        1013        1014      0.95753E-09
CT698        1019           0      0.26987E-13
RT698        1019           0      0.62873E+08
RT699        1018        1019      0.46160E-02
VT699        1017        1018 AC   0.00000E+00
LT699        1016        1017      0.95753E-09
CT700        1022           0      0.26987E-13
RT700        1022           0      0.62873E+08
RT701        1021        1022      0.46160E-02
VT701        1020        1021 AC   0.00000E+00
LT701        1019        1020      0.95753E-09
CT702        1025           0      0.26987E-13
RT702        1025           0      0.62873E+08
RT703        1024        1025      0.46160E-02
VT703        1023        1024 AC   0.00000E+00
LT703        1022        1023      0.95753E-09
CT704        1028           0      0.26987E-13
RT704        1028           0      0.62873E+08
RT705        1027        1028      0.46160E-02
VT705        1026        1027 AC   0.00000E+00
LT705        1025        1026      0.95753E-09
CT706        1031           0      0.26987E-13
RT706        1031           0      0.62873E+08
RT707        1030        1031      0.46160E-02
VT707        1029        1030 AC   0.00000E+00
LT707        1028        1029      0.95753E-09
CT708        1034           0      0.26987E-13
RT708        1034           0      0.62873E+08
RT709        1033        1034      0.46160E-02
VT709        1032        1033 AC   0.00000E+00
LT709        1031        1032      0.95753E-09
CT710        1037           0      0.26987E-13
RT710        1037           0      0.62873E+08
RT711        1036        1037      0.46160E-02
VT711        1035        1036 AC   0.00000E+00
LT711        1034        1035      0.95753E-09
CT712        1040           0      0.26987E-13
RT712        1040           0      0.62873E+08
RT713        1039        1040      0.46160E-02
VT713        1038        1039 AC   0.00000E+00
LT713        1037        1038      0.95753E-09
CT714        1043           0      0.26987E-13
RT714        1043           0      0.62873E+08
RT715        1042        1043      0.46160E-02
VT715        1041        1042 AC   0.00000E+00
LT715        1040        1041      0.95753E-09
CT716        1046           0      0.26987E-13
RT716        1046           0      0.62873E+08
RT717        1045        1046      0.46160E-02
VT717        1044        1045 AC   0.00000E+00
LT717        1043        1044      0.95753E-09
CT718        1049           0      0.26987E-13
RT718        1049           0      0.62873E+08
RT719        1048        1049      0.46160E-02
VT719        1047        1048 AC   0.00000E+00
LT719        1046        1047      0.95753E-09
CT720        1052           0      0.26987E-13
RT720        1052           0      0.62873E+08
RT721        1051        1052      0.46160E-02
VT721        1050        1051 AC   0.00000E+00
LT721        1049        1050      0.95753E-09
CT722        1055           0      0.26987E-13
RT722        1055           0      0.62873E+08
RT723        1054        1055      0.46160E-02
VT723        1053        1054 AC   0.00000E+00
LT723        1052        1053      0.95753E-09
CT724        1058           0      0.26987E-13
RT724        1058           0      0.62873E+08
RT725        1057        1058      0.46160E-02
VT725        1056        1057 AC   0.00000E+00
LT725        1055        1056      0.95753E-09
CT726        1061           0      0.26987E-13
RT726        1061           0      0.62873E+08
RT727        1060        1061      0.46160E-02
VT727        1059        1060 AC   0.00000E+00
LT727        1058        1059      0.95753E-09
CT728        1064           0      0.26987E-13
RT728        1064           0      0.62873E+08
RT729        1063        1064      0.46160E-02
VT729        1062        1063 AC   0.00000E+00
LT729        1061        1062      0.95753E-09
CT730        1067           0      0.26987E-13
RT730        1067           0      0.62873E+08
RT731        1066        1067      0.46160E-02
VT731        1065        1066 AC   0.00000E+00
LT731        1064        1065      0.95753E-09
CT732        1070           0      0.26987E-13
RT732        1070           0      0.62873E+08
RT733        1069        1070      0.46160E-02
VT733        1068        1069 AC   0.00000E+00
LT733        1067        1068      0.95753E-09
CT734        1073           0      0.26987E-13
RT734        1073           0      0.62873E+08
RT735        1072        1073      0.46160E-02
VT735        1071        1072 AC   0.00000E+00
LT735        1070        1071      0.95753E-09
CT736        1076           0      0.26987E-13
RT736        1076           0      0.62873E+08
RT737        1075        1076      0.46160E-02
VT737        1074        1075 AC   0.00000E+00
LT737        1073        1074      0.95753E-09
CT738        1079           0      0.26987E-13
RT738        1079           0      0.62873E+08
RT739        1078        1079      0.46160E-02
VT739        1077        1078 AC   0.00000E+00
LT739        1076        1077      0.95753E-09
CT740        1082           0      0.26987E-13
RT740        1082           0      0.62873E+08
RT741        1081        1082      0.46160E-02
VT741        1080        1081 AC   0.00000E+00
LT741        1079        1080      0.95753E-09
CT742        1085           0      0.26987E-13
RT742        1085           0      0.62873E+08
RT743        1084        1085      0.46160E-02
VT743        1083        1084 AC   0.00000E+00
LT743        1082        1083      0.95753E-09
CT744        1088           0      0.26987E-13
RT744        1088           0      0.62873E+08
RT745        1087        1088      0.46160E-02
VT745        1086        1087 AC   0.00000E+00
LT745        1085        1086      0.95753E-09
CT746        1091           0      0.26987E-13
RT746        1091           0      0.62873E+08
RT747        1090        1091      0.46160E-02
VT747        1089        1090 AC   0.00000E+00
LT747        1088        1089      0.95753E-09
CT748        1094           0      0.26987E-13
RT748        1094           0      0.62873E+08
RT749        1093        1094      0.46160E-02
VT749        1092        1093 AC   0.00000E+00
LT749        1091        1092      0.95753E-09
CT750        1097           0      0.26987E-13
RT750        1097           0      0.62873E+08
RT751        1096        1097      0.46160E-02
VT751        1095        1096 AC   0.00000E+00
LT751        1094        1095      0.95753E-09
CT752        1100           0      0.26987E-13
RT752        1100           0      0.62873E+08
RT753        1099        1100      0.46160E-02
VT753        1098        1099 AC   0.00000E+00
LT753        1097        1098      0.95753E-09
CT754        1103           0      0.26987E-13
RT754        1103           0      0.62873E+08
RT755        1102        1103      0.46160E-02
VT755        1101        1102 AC   0.00000E+00
LT755        1100        1101      0.95753E-09
CT756        1106           0      0.26987E-13
RT756        1106           0      0.62873E+08
RT757        1105        1106      0.46160E-02
VT757        1104        1105 AC   0.00000E+00
LT757        1103        1104      0.95753E-09
CT758        1109           0      0.26987E-13
RT758        1109           0      0.62873E+08
RT759        1108        1109      0.46160E-02
VT759        1107        1108 AC   0.00000E+00
LT759        1106        1107      0.95753E-09
CT760        1112           0      0.26987E-13
RT760        1112           0      0.62873E+08
RT761        1111        1112      0.46160E-02
VT761        1110        1111 AC   0.00000E+00
LT761        1109        1110      0.95753E-09
CT762        1115           0      0.26987E-13
RT762        1115           0      0.62873E+08
RT763        1114        1115      0.46160E-02
VT763        1113        1114 AC   0.00000E+00
LT763        1112        1113      0.95753E-09
CT764        1118           0      0.26987E-13
RT764        1118           0      0.62873E+08
RT765        1117        1118      0.46160E-02
VT765        1116        1117 AC   0.00000E+00
LT765        1115        1116      0.95753E-09
CT766        1121           0      0.26987E-13
RT766        1121           0      0.62873E+08
RT767        1120        1121      0.46160E-02
VT767        1119        1120 AC   0.00000E+00
LT767        1118        1119      0.95753E-09
CT768        1124           0      0.26987E-13
RT768        1124           0      0.62873E+08
RT769        1123        1124      0.46160E-02
VT769        1122        1123 AC   0.00000E+00
LT769        1121        1122      0.95753E-09
CT770        1127           0      0.56354E-13
RT770        1127           0      0.62873E+08
RT771        1126        1127      0.46160E-02
VT771        1125        1126 AC   0.00000E+00
LT771        1124        1125      0.95753E-09
CT772        1128           0      0.56354E-13
RT772        1128           0      0.62873E+08
CT773        1131           0      0.26987E-13
RT773        1131           0      0.62873E+08
RT774        1130        1131      0.46160E-02
VT774        1129        1130 AC   0.00000E+00
LT774        1128        1129      0.95753E-09
CT775        1134           0      0.26987E-13
RT775        1134           0      0.62873E+08
RT776        1133        1134      0.46160E-02
VT776        1132        1133 AC   0.00000E+00
LT776        1131        1132      0.95753E-09
CT777        1137           0      0.26987E-13
RT777        1137           0      0.62873E+08
RT778        1136        1137      0.46160E-02
VT778        1135        1136 AC   0.00000E+00
LT778        1134        1135      0.95753E-09
CT779        1140           0      0.26987E-13
RT779        1140           0      0.62873E+08
RT780        1139        1140      0.46160E-02
VT780        1138        1139 AC   0.00000E+00
LT780        1137        1138      0.95753E-09
CT781        1143           0      0.26987E-13
RT781        1143           0      0.62873E+08
RT782        1142        1143      0.46160E-02
VT782        1141        1142 AC   0.00000E+00
LT782        1140        1141      0.95753E-09
CT783        1146           0      0.26987E-13
RT783        1146           0      0.62873E+08
RT784        1145        1146      0.46160E-02
VT784        1144        1145 AC   0.00000E+00
LT784        1143        1144      0.95753E-09
CT785        1149           0      0.26987E-13
RT785        1149           0      0.62873E+08
RT786        1148        1149      0.46160E-02
VT786        1147        1148 AC   0.00000E+00
LT786        1146        1147      0.95753E-09
CT787        1152           0      0.26987E-13
RT787        1152           0      0.62873E+08
RT788        1151        1152      0.46160E-02
VT788        1150        1151 AC   0.00000E+00
LT788        1149        1150      0.95753E-09
CT789        1155           0      0.26987E-13
RT789        1155           0      0.62873E+08
RT790        1154        1155      0.46160E-02
VT790        1153        1154 AC   0.00000E+00
LT790        1152        1153      0.95753E-09
CT791        1158           0      0.26987E-13
RT791        1158           0      0.62873E+08
RT792        1157        1158      0.46160E-02
VT792        1156        1157 AC   0.00000E+00
LT792        1155        1156      0.95753E-09
CT793        1161           0      0.26987E-13
RT793        1161           0      0.62873E+08
RT794        1160        1161      0.46160E-02
VT794        1159        1160 AC   0.00000E+00
LT794        1158        1159      0.95753E-09
CT795        1164           0      0.26987E-13
RT795        1164           0      0.62873E+08
RT796        1163        1164      0.46160E-02
VT796        1162        1163 AC   0.00000E+00
LT796        1161        1162      0.95753E-09
CT797        1167           0      0.26987E-13
RT797        1167           0      0.62873E+08
RT798        1166        1167      0.46160E-02
VT798        1165        1166 AC   0.00000E+00
LT798        1164        1165      0.95753E-09
CT799        1170           0      0.26987E-13
RT799        1170           0      0.62873E+08
RT800        1169        1170      0.46160E-02
VT800        1168        1169 AC   0.00000E+00
LT800        1167        1168      0.95753E-09
CT801        1173           0      0.26987E-13
RT801        1173           0      0.62873E+08
RT802        1172        1173      0.46160E-02
VT802        1171        1172 AC   0.00000E+00
LT802        1170        1171      0.95753E-09
CT803        1176           0      0.26987E-13
RT803        1176           0      0.62873E+08
RT804        1175        1176      0.46160E-02
VT804        1174        1175 AC   0.00000E+00
LT804        1173        1174      0.95753E-09
CT805        1179           0      0.26987E-13
RT805        1179           0      0.62873E+08
RT806        1178        1179      0.46160E-02
VT806        1177        1178 AC   0.00000E+00
LT806        1176        1177      0.95753E-09
CT807        1182           0      0.26987E-13
RT807        1182           0      0.62873E+08
RT808        1181        1182      0.46160E-02
VT808        1180        1181 AC   0.00000E+00
LT808        1179        1180      0.95753E-09
CT809        1185           0      0.26987E-13
RT809        1185           0      0.62873E+08
RT810        1184        1185      0.46160E-02
VT810        1183        1184 AC   0.00000E+00
LT810        1182        1183      0.95753E-09
CT811        1188           0      0.26987E-13
RT811        1188           0      0.62873E+08
RT812        1187        1188      0.46160E-02
VT812        1186        1187 AC   0.00000E+00
LT812        1185        1186      0.95753E-09
CT813        1191           0      0.26987E-13
RT813        1191           0      0.62873E+08
RT814        1190        1191      0.46160E-02
VT814        1189        1190 AC   0.00000E+00
LT814        1188        1189      0.95753E-09
CT815        1194           0      0.26987E-13
RT815        1194           0      0.62873E+08
RT816        1193        1194      0.46160E-02
VT816        1192        1193 AC   0.00000E+00
LT816        1191        1192      0.95753E-09
CT817        1197           0      0.26987E-13
RT817        1197           0      0.62873E+08
RT818        1196        1197      0.46160E-02
VT818        1195        1196 AC   0.00000E+00
LT818        1194        1195      0.95753E-09
CT819        1200           0      0.26987E-13
RT819        1200           0      0.62873E+08
RT820        1199        1200      0.46160E-02
VT820        1198        1199 AC   0.00000E+00
LT820        1197        1198      0.95753E-09
CT821        1203           0      0.26987E-13
RT821        1203           0      0.62873E+08
RT822        1202        1203      0.46160E-02
VT822        1201        1202 AC   0.00000E+00
LT822        1200        1201      0.95753E-09
CT823        1206           0      0.26987E-13
RT823        1206           0      0.62873E+08
RT824        1205        1206      0.46160E-02
VT824        1204        1205 AC   0.00000E+00
LT824        1203        1204      0.95753E-09
CT825        1209           0      0.26987E-13
RT825        1209           0      0.62873E+08
RT826        1208        1209      0.46160E-02
VT826        1207        1208 AC   0.00000E+00
LT826        1206        1207      0.95753E-09
CT827        1212           0      0.26987E-13
RT827        1212           0      0.62873E+08
RT828        1211        1212      0.46160E-02
VT828        1210        1211 AC   0.00000E+00
LT828        1209        1210      0.95753E-09
CT829        1215           0      0.26987E-13
RT829        1215           0      0.62873E+08
RT830        1214        1215      0.46160E-02
VT830        1213        1214 AC   0.00000E+00
LT830        1212        1213      0.95753E-09
CT831        1218           0      0.26987E-13
RT831        1218           0      0.62873E+08
RT832        1217        1218      0.46160E-02
VT832        1216        1217 AC   0.00000E+00
LT832        1215        1216      0.95753E-09
CT833        1221           0      0.26987E-13
RT833        1221           0      0.62873E+08
RT834        1220        1221      0.46160E-02
VT834        1219        1220 AC   0.00000E+00
LT834        1218        1219      0.95753E-09
CT835        1224           0      0.26987E-13
RT835        1224           0      0.62873E+08
RT836        1223        1224      0.46160E-02
VT836        1222        1223 AC   0.00000E+00
LT836        1221        1222      0.95753E-09
CT837        1227           0      0.26987E-13
RT837        1227           0      0.62873E+08
RT838        1226        1227      0.46160E-02
VT838        1225        1226 AC   0.00000E+00
LT838        1224        1225      0.95753E-09
CT839        1230           0      0.26987E-13
RT839        1230           0      0.62873E+08
RT840        1229        1230      0.46160E-02
VT840        1228        1229 AC   0.00000E+00
LT840        1227        1228      0.95753E-09
CT841        1233           0      0.26987E-13
RT841        1233           0      0.62873E+08
RT842        1232        1233      0.46160E-02
VT842        1231        1232 AC   0.00000E+00
LT842        1230        1231      0.95753E-09
CT843        1236           0      0.26987E-13
RT843        1236           0      0.62873E+08
RT844        1235        1236      0.46160E-02
VT844        1234        1235 AC   0.00000E+00
LT844        1233        1234      0.95753E-09
CT845        1239           0      0.26987E-13
RT845        1239           0      0.62873E+08
RT846        1238        1239      0.46160E-02
VT846        1237        1238 AC   0.00000E+00
LT846        1236        1237      0.95753E-09
CT847        1242           0      0.26987E-13
RT847        1242           0      0.62873E+08
RT848        1241        1242      0.46160E-02
VT848        1240        1241 AC   0.00000E+00
LT848        1239        1240      0.95753E-09
CT849        1245           0      0.26987E-13
RT849        1245           0      0.62873E+08
RT850        1244        1245      0.46160E-02
VT850        1243        1244 AC   0.00000E+00
LT850        1242        1243      0.95753E-09
CT851        1248           0      0.26987E-13
RT851        1248           0      0.62873E+08
RT852        1247        1248      0.46160E-02
VT852        1246        1247 AC   0.00000E+00
LT852        1245        1246      0.95753E-09
CT853        1251           0      0.26987E-13
RT853        1251           0      0.62873E+08
RT854        1250        1251      0.46160E-02
VT854        1249        1250 AC   0.00000E+00
LT854        1248        1249      0.95753E-09
CT855        1254           0      0.26987E-13
RT855        1254           0      0.62873E+08
RT856        1253        1254      0.46160E-02
VT856        1252        1253 AC   0.00000E+00
LT856        1251        1252      0.95753E-09
CT857        1257           0      0.26987E-13
RT857        1257           0      0.62873E+08
RT858        1256        1257      0.46160E-02
VT858        1255        1256 AC   0.00000E+00
LT858        1254        1255      0.95753E-09
CT859        1260           0      0.26987E-13
RT859        1260           0      0.62873E+08
RT860        1259        1260      0.46160E-02
VT860        1258        1259 AC   0.00000E+00
LT860        1257        1258      0.95753E-09
CT861        1263           0      0.26987E-13
RT861        1263           0      0.62873E+08
RT862        1262        1263      0.46160E-02
VT862        1261        1262 AC   0.00000E+00
LT862        1260        1261      0.95753E-09
CT863        1266           0      0.26987E-13
RT863        1266           0      0.62873E+08
RT864        1265        1266      0.46160E-02
VT864        1264        1265 AC   0.00000E+00
LT864        1263        1264      0.95753E-09
CT865        1269           0      0.26987E-13
RT865        1269           0      0.62873E+08
RT866        1268        1269      0.46160E-02
VT866        1267        1268 AC   0.00000E+00
LT866        1266        1267      0.95753E-09
CT867        1272           0      0.26987E-13
RT867        1272           0      0.62873E+08
RT868        1271        1272      0.46160E-02
VT868        1270        1271 AC   0.00000E+00
LT868        1269        1270      0.95753E-09
CT869        1275           0      0.26987E-13
RT869        1275           0      0.62873E+08
RT870        1274        1275      0.46160E-02
VT870        1273        1274 AC   0.00000E+00
LT870        1272        1273      0.95753E-09
CT871        1278           0      0.26987E-13
RT871        1278           0      0.62873E+08
RT872        1277        1278      0.46160E-02
VT872        1276        1277 AC   0.00000E+00
LT872        1275        1276      0.95753E-09
CT873        1281           0      0.26987E-13
RT873        1281           0      0.62873E+08
RT874        1280        1281      0.46160E-02
VT874        1279        1280 AC   0.00000E+00
LT874        1278        1279      0.95753E-09
CT875        1284           0      0.26987E-13
RT875        1284           0      0.62873E+08
RT876        1283        1284      0.46160E-02
VT876        1282        1283 AC   0.00000E+00
LT876        1281        1282      0.95753E-09
CT877        1287           0      0.26987E-13
RT877        1287           0      0.62873E+08
RT878        1286        1287      0.46160E-02
VT878        1285        1286 AC   0.00000E+00
LT878        1284        1285      0.95753E-09
CT879        1290           0      0.26987E-13
RT879        1290           0      0.62873E+08
RT880        1289        1290      0.46160E-02
VT880        1288        1289 AC   0.00000E+00
LT880        1287        1288      0.95753E-09
CT881        1293           0      0.26987E-13
RT881        1293           0      0.62873E+08
RT882        1292        1293      0.46160E-02
VT882        1291        1292 AC   0.00000E+00
LT882        1290        1291      0.95753E-09
CT883        1296           0      0.26987E-13
RT883        1296           0      0.62873E+08
RT884        1295        1296      0.46160E-02
VT884        1294        1295 AC   0.00000E+00
LT884        1293        1294      0.95753E-09
CT885        1299           0      0.26987E-13
RT885        1299           0      0.62873E+08
RT886        1298        1299      0.46160E-02
VT886        1297        1298 AC   0.00000E+00
LT886        1296        1297      0.95753E-09
CT887        1302           0      0.26987E-13
RT887        1302           0      0.62873E+08
RT888        1301        1302      0.46160E-02
VT888        1300        1301 AC   0.00000E+00
LT888        1299        1300      0.95753E-09
CT889        1305           0      0.26987E-13
RT889        1305           0      0.62873E+08
RT890        1304        1305      0.46160E-02
VT890        1303        1304 AC   0.00000E+00
LT890        1302        1303      0.95753E-09
CT891        1308           0      0.26987E-13
RT891        1308           0      0.62873E+08
RT892        1307        1308      0.46160E-02
VT892        1306        1307 AC   0.00000E+00
LT892        1305        1306      0.95753E-09
CT893        1311           0      0.26987E-13
RT893        1311           0      0.62873E+08
RT894        1310        1311      0.46160E-02
VT894        1309        1310 AC   0.00000E+00
LT894        1308        1309      0.95753E-09
CT895        1314           0      0.26987E-13
RT895        1314           0      0.62873E+08
RT896        1313        1314      0.46160E-02
VT896        1312        1313 AC   0.00000E+00
LT896        1311        1312      0.95753E-09
CT897        1317           0      0.26987E-13
RT897        1317           0      0.62873E+08
RT898        1316        1317      0.46160E-02
VT898        1315        1316 AC   0.00000E+00
LT898        1314        1315      0.95753E-09
CT899        1320           0      0.56354E-13
RT899        1320           0      0.62873E+08
RT900        1319        1320      0.46160E-02
VT900        1318        1319 AC   0.00000E+00
LT900        1317        1318      0.95753E-09
CT901        1321           0      0.56354E-13
RT901        1321           0      0.62873E+08
CT902        1324           0      0.26987E-13
RT902        1324           0      0.62873E+08
RT903        1323        1324      0.46160E-02
VT903        1322        1323 AC   0.00000E+00
LT903        1321        1322      0.95753E-09
CT904        1327           0      0.26987E-13
RT904        1327           0      0.62873E+08
RT905        1326        1327      0.46160E-02
VT905        1325        1326 AC   0.00000E+00
LT905        1324        1325      0.95753E-09
CT906        1330           0      0.26987E-13
RT906        1330           0      0.62873E+08
RT907        1329        1330      0.46160E-02
VT907        1328        1329 AC   0.00000E+00
LT907        1327        1328      0.95753E-09
CT908        1333           0      0.26987E-13
RT908        1333           0      0.62873E+08
RT909        1332        1333      0.46160E-02
VT909        1331        1332 AC   0.00000E+00
LT909        1330        1331      0.95753E-09
CT910        1336           0      0.26987E-13
RT910        1336           0      0.62873E+08
RT911        1335        1336      0.46160E-02
VT911        1334        1335 AC   0.00000E+00
LT911        1333        1334      0.95753E-09
CT912        1339           0      0.26987E-13
RT912        1339           0      0.62873E+08
RT913        1338        1339      0.46160E-02
VT913        1337        1338 AC   0.00000E+00
LT913        1336        1337      0.95753E-09
CT914        1342           0      0.26987E-13
RT914        1342           0      0.62873E+08
RT915        1341        1342      0.46160E-02
VT915        1340        1341 AC   0.00000E+00
LT915        1339        1340      0.95753E-09
CT916        1345           0      0.26987E-13
RT916        1345           0      0.62873E+08
RT917        1344        1345      0.46160E-02
VT917        1343        1344 AC   0.00000E+00
LT917        1342        1343      0.95753E-09
CT918        1348           0      0.26987E-13
RT918        1348           0      0.62873E+08
RT919        1347        1348      0.46160E-02
VT919        1346        1347 AC   0.00000E+00
LT919        1345        1346      0.95753E-09
CT920        1351           0      0.26987E-13
RT920        1351           0      0.62873E+08
RT921        1350        1351      0.46160E-02
VT921        1349        1350 AC   0.00000E+00
LT921        1348        1349      0.95753E-09
CT922        1354           0      0.26987E-13
RT922        1354           0      0.62873E+08
RT923        1353        1354      0.46160E-02
VT923        1352        1353 AC   0.00000E+00
LT923        1351        1352      0.95753E-09
CT924        1357           0      0.26987E-13
RT924        1357           0      0.62873E+08
RT925        1356        1357      0.46160E-02
VT925        1355        1356 AC   0.00000E+00
LT925        1354        1355      0.95753E-09
CT926        1360           0      0.26987E-13
RT926        1360           0      0.62873E+08
RT927        1359        1360      0.46160E-02
VT927        1358        1359 AC   0.00000E+00
LT927        1357        1358      0.95753E-09
CT928        1363           0      0.26987E-13
RT928        1363           0      0.62873E+08
RT929        1362        1363      0.46160E-02
VT929        1361        1362 AC   0.00000E+00
LT929        1360        1361      0.95753E-09
CT930        1366           0      0.26987E-13
RT930        1366           0      0.62873E+08
RT931        1365        1366      0.46160E-02
VT931        1364        1365 AC   0.00000E+00
LT931        1363        1364      0.95753E-09
CT932        1369           0      0.26987E-13
RT932        1369           0      0.62873E+08
RT933        1368        1369      0.46160E-02
VT933        1367        1368 AC   0.00000E+00
LT933        1366        1367      0.95753E-09
CT934        1372           0      0.26987E-13
RT934        1372           0      0.62873E+08
RT935        1371        1372      0.46160E-02
VT935        1370        1371 AC   0.00000E+00
LT935        1369        1370      0.95753E-09
CT936        1375           0      0.26987E-13
RT936        1375           0      0.62873E+08
RT937        1374        1375      0.46160E-02
VT937        1373        1374 AC   0.00000E+00
LT937        1372        1373      0.95753E-09
CT938        1378           0      0.26987E-13
RT938        1378           0      0.62873E+08
RT939        1377        1378      0.46160E-02
VT939        1376        1377 AC   0.00000E+00
LT939        1375        1376      0.95753E-09
CT940        1381           0      0.26987E-13
RT940        1381           0      0.62873E+08
RT941        1380        1381      0.46160E-02
VT941        1379        1380 AC   0.00000E+00
LT941        1378        1379      0.95753E-09
CT942        1384           0      0.26987E-13
RT942        1384           0      0.62873E+08
RT943        1383        1384      0.46160E-02
VT943        1382        1383 AC   0.00000E+00
LT943        1381        1382      0.95753E-09
CT944        1387           0      0.26987E-13
RT944        1387           0      0.62873E+08
RT945        1386        1387      0.46160E-02
VT945        1385        1386 AC   0.00000E+00
LT945        1384        1385      0.95753E-09
CT946        1390           0      0.26987E-13
RT946        1390           0      0.62873E+08
RT947        1389        1390      0.46160E-02
VT947        1388        1389 AC   0.00000E+00
LT947        1387        1388      0.95753E-09
CT948        1393           0      0.26987E-13
RT948        1393           0      0.62873E+08
RT949        1392        1393      0.46160E-02
VT949        1391        1392 AC   0.00000E+00
LT949        1390        1391      0.95753E-09
CT950        1396           0      0.26987E-13
RT950        1396           0      0.62873E+08
RT951        1395        1396      0.46160E-02
VT951        1394        1395 AC   0.00000E+00
LT951        1393        1394      0.95753E-09
CT952        1399           0      0.26987E-13
RT952        1399           0      0.62873E+08
RT953        1398        1399      0.46160E-02
VT953        1397        1398 AC   0.00000E+00
LT953        1396        1397      0.95753E-09
CT954        1402           0      0.26987E-13
RT954        1402           0      0.62873E+08
RT955        1401        1402      0.46160E-02
VT955        1400        1401 AC   0.00000E+00
LT955        1399        1400      0.95753E-09
CT956        1405           0      0.26987E-13
RT956        1405           0      0.62873E+08
RT957        1404        1405      0.46160E-02
VT957        1403        1404 AC   0.00000E+00
LT957        1402        1403      0.95753E-09
CT958        1408           0      0.26987E-13
RT958        1408           0      0.62873E+08
RT959        1407        1408      0.46160E-02
VT959        1406        1407 AC   0.00000E+00
LT959        1405        1406      0.95753E-09
CT960        1411           0      0.26987E-13
RT960        1411           0      0.62873E+08
RT961        1410        1411      0.46160E-02
VT961        1409        1410 AC   0.00000E+00
LT961        1408        1409      0.95753E-09
CT962        1414           0      0.26987E-13
RT962        1414           0      0.62873E+08
RT963        1413        1414      0.46160E-02
VT963        1412        1413 AC   0.00000E+00
LT963        1411        1412      0.95753E-09
CT964        1417           0      0.26987E-13
RT964        1417           0      0.62873E+08
RT965        1416        1417      0.46160E-02
VT965        1415        1416 AC   0.00000E+00
LT965        1414        1415      0.95753E-09
CT966        1420           0      0.26987E-13
RT966        1420           0      0.62873E+08
RT967        1419        1420      0.46160E-02
VT967        1418        1419 AC   0.00000E+00
LT967        1417        1418      0.95753E-09
CT968        1423           0      0.26987E-13
RT968        1423           0      0.62873E+08
RT969        1422        1423      0.46160E-02
VT969        1421        1422 AC   0.00000E+00
LT969        1420        1421      0.95753E-09
CT970        1426           0      0.26987E-13
RT970        1426           0      0.62873E+08
RT971        1425        1426      0.46160E-02
VT971        1424        1425 AC   0.00000E+00
LT971        1423        1424      0.95753E-09
CT972        1429           0      0.26987E-13
RT972        1429           0      0.62873E+08
RT973        1428        1429      0.46160E-02
VT973        1427        1428 AC   0.00000E+00
LT973        1426        1427      0.95753E-09
CT974        1432           0      0.26987E-13
RT974        1432           0      0.62873E+08
RT975        1431        1432      0.46160E-02
VT975        1430        1431 AC   0.00000E+00
LT975        1429        1430      0.95753E-09
CT976        1435           0      0.26987E-13
RT976        1435           0      0.62873E+08
RT977        1434        1435      0.46160E-02
VT977        1433        1434 AC   0.00000E+00
LT977        1432        1433      0.95753E-09
CT978        1438           0      0.26987E-13
RT978        1438           0      0.62873E+08
RT979        1437        1438      0.46160E-02
VT979        1436        1437 AC   0.00000E+00
LT979        1435        1436      0.95753E-09
CT980        1441           0      0.26987E-13
RT980        1441           0      0.62873E+08
RT981        1440        1441      0.46160E-02
VT981        1439        1440 AC   0.00000E+00
LT981        1438        1439      0.95753E-09
CT982        1444           0      0.26987E-13
RT982        1444           0      0.62873E+08
RT983        1443        1444      0.46160E-02
VT983        1442        1443 AC   0.00000E+00
LT983        1441        1442      0.95753E-09
CT984        1447           0      0.26987E-13
RT984        1447           0      0.62873E+08
RT985        1446        1447      0.46160E-02
VT985        1445        1446 AC   0.00000E+00
LT985        1444        1445      0.95753E-09
CT986        1450           0      0.26987E-13
RT986        1450           0      0.62873E+08
RT987        1449        1450      0.46160E-02
VT987        1448        1449 AC   0.00000E+00
LT987        1447        1448      0.95753E-09
CT988        1453           0      0.26987E-13
RT988        1453           0      0.62873E+08
RT989        1452        1453      0.46160E-02
VT989        1451        1452 AC   0.00000E+00
LT989        1450        1451      0.95753E-09
CT990        1456           0      0.26987E-13
RT990        1456           0      0.62873E+08
RT991        1455        1456      0.46160E-02
VT991        1454        1455 AC   0.00000E+00
LT991        1453        1454      0.95753E-09
CT992        1459           0      0.26987E-13
RT992        1459           0      0.62873E+08
RT993        1458        1459      0.46160E-02
VT993        1457        1458 AC   0.00000E+00
LT993        1456        1457      0.95753E-09
CT994        1462           0      0.26987E-13
RT994        1462           0      0.62873E+08
RT995        1461        1462      0.46160E-02
VT995        1460        1461 AC   0.00000E+00
LT995        1459        1460      0.95753E-09
CT996        1465           0      0.26987E-13
RT996        1465           0      0.62873E+08
RT997        1464        1465      0.46160E-02
VT997        1463        1464 AC   0.00000E+00
LT997        1462        1463      0.95753E-09
CT998        1468           0      0.26987E-13
RT998        1468           0      0.62873E+08
RT999        1467        1468      0.46160E-02
VT999        1466        1467 AC   0.00000E+00
LT999        1465        1466      0.95753E-09
CT1000        1471           0      0.26987E-13
RT1000        1471           0      0.62873E+08
RT1001        1470        1471      0.46160E-02
VT1001        1469        1470 AC   0.00000E+00
LT1001        1468        1469      0.95753E-09
CT1002        1474           0      0.26987E-13
RT1002        1474           0      0.62873E+08
RT1003        1473        1474      0.46160E-02
VT1003        1472        1473 AC   0.00000E+00
LT1003        1471        1472      0.95753E-09
CT1004        1477           0      0.26987E-13
RT1004        1477           0      0.62873E+08
RT1005        1476        1477      0.46160E-02
VT1005        1475        1476 AC   0.00000E+00
LT1005        1474        1475      0.95753E-09
CT1006        1480           0      0.26987E-13
RT1006        1480           0      0.62873E+08
RT1007        1479        1480      0.46160E-02
VT1007        1478        1479 AC   0.00000E+00
LT1007        1477        1478      0.95753E-09
CT1008        1483           0      0.26987E-13
RT1008        1483           0      0.62873E+08
RT1009        1482        1483      0.46160E-02
VT1009        1481        1482 AC   0.00000E+00
LT1009        1480        1481      0.95753E-09
CT1010        1486           0      0.26987E-13
RT1010        1486           0      0.62873E+08
RT1011        1485        1486      0.46160E-02
VT1011        1484        1485 AC   0.00000E+00
LT1011        1483        1484      0.95753E-09
CT1012        1489           0      0.26987E-13
RT1012        1489           0      0.62873E+08
RT1013        1488        1489      0.46160E-02
VT1013        1487        1488 AC   0.00000E+00
LT1013        1486        1487      0.95753E-09
CT1014        1492           0      0.26987E-13
RT1014        1492           0      0.62873E+08
RT1015        1491        1492      0.46160E-02
VT1015        1490        1491 AC   0.00000E+00
LT1015        1489        1490      0.95753E-09
CT1016        1495           0      0.26987E-13
RT1016        1495           0      0.62873E+08
RT1017        1494        1495      0.46160E-02
VT1017        1493        1494 AC   0.00000E+00
LT1017        1492        1493      0.95753E-09
CT1018        1498           0      0.26987E-13
RT1018        1498           0      0.62873E+08
RT1019        1497        1498      0.46160E-02
VT1019        1496        1497 AC   0.00000E+00
LT1019        1495        1496      0.95753E-09
CT1020        1501           0      0.26987E-13
RT1020        1501           0      0.62873E+08
RT1021        1500        1501      0.46160E-02
VT1021        1499        1500 AC   0.00000E+00
LT1021        1498        1499      0.95753E-09
CT1022        1504           0      0.26987E-13
RT1022        1504           0      0.62873E+08
RT1023        1503        1504      0.46160E-02
VT1023        1502        1503 AC   0.00000E+00
LT1023        1501        1502      0.95753E-09
CT1024        1507           0      0.26987E-13
RT1024        1507           0      0.62873E+08
RT1025        1506        1507      0.46160E-02
VT1025        1505        1506 AC   0.00000E+00
LT1025        1504        1505      0.95753E-09
CT1026        1510           0      0.26987E-13
RT1026        1510           0      0.62873E+08
RT1027        1509        1510      0.46160E-02
VT1027        1508        1509 AC   0.00000E+00
LT1027        1507        1508      0.95753E-09
CT1028        1513           0      0.56354E-13
RT1028        1513           0      0.62873E+08
RT1029        1512        1513      0.46160E-02
VT1029        1511        1512 AC   0.00000E+00
LT1029        1510        1511      0.95753E-09
CT1030        1514           0      0.56354E-13
RT1030        1514           0      0.62873E+08
CT1031        1517           0      0.26987E-13
RT1031        1517           0      0.62873E+08
RT1032        1516        1517      0.46160E-02
VT1032        1515        1516 AC   0.00000E+00
LT1032        1514        1515      0.95753E-09
CT1033        1520           0      0.26987E-13
RT1033        1520           0      0.62873E+08
RT1034        1519        1520      0.46160E-02
VT1034        1518        1519 AC   0.00000E+00
LT1034        1517        1518      0.95753E-09
CT1035        1523           0      0.26987E-13
RT1035        1523           0      0.62873E+08
RT1036        1522        1523      0.46160E-02
VT1036        1521        1522 AC   0.00000E+00
LT1036        1520        1521      0.95753E-09
CT1037        1526           0      0.26987E-13
RT1037        1526           0      0.62873E+08
RT1038        1525        1526      0.46160E-02
VT1038        1524        1525 AC   0.00000E+00
LT1038        1523        1524      0.95753E-09
CT1039        1529           0      0.48472E-13
RT1039        1529           0      0.62873E+08
RT1040        1528        1529      0.46160E-02
VT1040        1527        1528 AC   0.00000E+00
LT1040        1526        1527      0.64812E-09
CT1041        1532           0      0.48472E-13
RT1041        1532           0      0.62873E+08
RT1042        1531        1532      0.46160E-02
VT1042        1530        1531 AC   0.00000E+00
LT1042        1529        1530      0.33871E-09
CT1043        1535           0      0.48472E-13
RT1043        1535           0      0.62873E+08
RT1044        1534        1535      0.46160E-02
VT1044        1533        1534 AC   0.00000E+00
LT1044        1532        1533      0.33871E-09
CT1045        1538           0      0.48472E-13
RT1045        1538           0      0.62873E+08
RT1046        1537        1538      0.46160E-02
VT1046        1536        1537 AC   0.00000E+00
LT1046        1535        1536      0.33871E-09
CT1047        1541           0      0.48472E-13
RT1047        1541           0      0.62873E+08
RT1048        1540        1541      0.46160E-02
VT1048        1539        1540 AC   0.00000E+00
LT1048        1538        1539      0.33871E-09
CT1049        1544           0      0.48472E-13
RT1049        1544           0      0.62873E+08
RT1050        1543        1544      0.46160E-02
VT1050        1542        1543 AC   0.00000E+00
LT1050        1541        1542      0.33871E-09
CT1051        1547           0      0.48472E-13
RT1051        1547           0      0.62873E+08
RT1052        1546        1547      0.46160E-02
VT1052        1545        1546 AC   0.00000E+00
LT1052        1544        1545      0.33871E-09
CT1053        1550           0      0.48472E-13
RT1053        1550           0      0.62873E+08
RT1054        1549        1550      0.46160E-02
VT1054        1548        1549 AC   0.00000E+00
LT1054        1547        1548      0.33871E-09
CT1055        1553           0      0.48472E-13
RT1055        1553           0      0.62873E+08
RT1056        1552        1553      0.46160E-02
VT1056        1551        1552 AC   0.00000E+00
LT1056        1550        1551      0.33871E-09
CT1057        1556           0      0.48472E-13
RT1057        1556           0      0.62873E+08
RT1058        1555        1556      0.46160E-02
VT1058        1554        1555 AC   0.00000E+00
LT1058        1553        1554      0.33871E-09
CT1059        1559           0      0.48472E-13
RT1059        1559           0      0.62873E+08
RT1060        1558        1559      0.46160E-02
VT1060        1557        1558 AC   0.00000E+00
LT1060        1556        1557      0.33871E-09
CT1061        1562           0      0.48472E-13
RT1061        1562           0      0.62873E+08
RT1062        1561        1562      0.46160E-02
VT1062        1560        1561 AC   0.00000E+00
LT1062        1559        1560      0.33871E-09
CT1063        1565           0      0.48472E-13
RT1063        1565           0      0.62873E+08
RT1064        1564        1565      0.46160E-02
VT1064        1563        1564 AC   0.00000E+00
LT1064        1562        1563      0.33871E-09
CT1065        1568           0      0.48472E-13
RT1065        1568           0      0.62873E+08
RT1066        1567        1568      0.46160E-02
VT1066        1566        1567 AC   0.00000E+00
LT1066        1565        1566      0.33871E-09
CT1067        1571           0      0.48472E-13
RT1067        1571           0      0.62873E+08
RT1068        1570        1571      0.46160E-02
VT1068        1569        1570 AC   0.00000E+00
LT1068        1568        1569      0.33871E-09
CT1069        1574           0      0.48472E-13
RT1069        1574           0      0.62873E+08
RT1070        1573        1574      0.46160E-02
VT1070        1572        1573 AC   0.00000E+00
LT1070        1571        1572      0.33871E-09
CT1071        1577           0      0.48472E-13
RT1071        1577           0      0.62873E+08
RT1072        1576        1577      0.46160E-02
VT1072        1575        1576 AC   0.00000E+00
LT1072        1574        1575      0.33871E-09
CT1073        1580           0      0.48472E-13
RT1073        1580           0      0.62873E+08
RT1074        1579        1580      0.46160E-02
VT1074        1578        1579 AC   0.00000E+00
LT1074        1577        1578      0.33871E-09
CT1075        1583           0      0.48472E-13
RT1075        1583           0      0.62873E+08
RT1076        1582        1583      0.46160E-02
VT1076        1581        1582 AC   0.00000E+00
LT1076        1580        1581      0.33871E-09
CT1077        1586           0      0.48472E-13
RT1077        1586           0      0.62873E+08
RT1078        1585        1586      0.46160E-02
VT1078        1584        1585 AC   0.00000E+00
LT1078        1583        1584      0.33871E-09
CT1079        1589           0      0.48472E-13
RT1079        1589           0      0.62873E+08
RT1080        1588        1589      0.46160E-02
VT1080        1587        1588 AC   0.00000E+00
LT1080        1586        1587      0.33871E-09
CT1081        1592           0      0.48472E-13
RT1081        1592           0      0.62873E+08
RT1082        1591        1592      0.46160E-02
VT1082        1590        1591 AC   0.00000E+00
LT1082        1589        1590      0.33871E-09
CT1083        1595           0      0.48472E-13
RT1083        1595           0      0.62873E+08
RT1084        1594        1595      0.46160E-02
VT1084        1593        1594 AC   0.00000E+00
LT1084        1592        1593      0.33871E-09
CT1085        1598           0      0.48472E-13
RT1085        1598           0      0.62873E+08
RT1086        1597        1598      0.46160E-02
VT1086        1596        1597 AC   0.00000E+00
LT1086        1595        1596      0.33871E-09
CT1087        1601           0      0.48472E-13
RT1087        1601           0      0.62873E+08
RT1088        1600        1601      0.46160E-02
VT1088        1599        1600 AC   0.00000E+00
LT1088        1598        1599      0.33871E-09
CT1089        1604           0      0.48472E-13
RT1089        1604           0      0.62873E+08
RT1090        1603        1604      0.46160E-02
VT1090        1602        1603 AC   0.00000E+00
LT1090        1601        1602      0.33871E-09
CT1091        1607           0      0.48472E-13
RT1091        1607           0      0.62873E+08
RT1092        1606        1607      0.46160E-02
VT1092        1605        1606 AC   0.00000E+00
LT1092        1604        1605      0.33871E-09
CT1093        1610           0      0.48472E-13
RT1093        1610           0      0.62873E+08
RT1094        1609        1610      0.46160E-02
VT1094        1608        1609 AC   0.00000E+00
LT1094        1607        1608      0.33871E-09
CT1095        1613           0      0.48472E-13
RT1095        1613           0      0.62873E+08
RT1096        1612        1613      0.46160E-02
VT1096        1611        1612 AC   0.00000E+00
LT1096        1610        1611      0.33871E-09
CT1097        1616           0      0.48472E-13
RT1097        1616           0      0.62873E+08
RT1098        1615        1616      0.46160E-02
VT1098        1614        1615 AC   0.00000E+00
LT1098        1613        1614      0.33871E-09
CT1099        1619           0      0.48472E-13
RT1099        1619           0      0.62873E+08
RT1100        1618        1619      0.46160E-02
VT1100        1617        1618 AC   0.00000E+00
LT1100        1616        1617      0.33871E-09
CT1101        1622           0      0.48472E-13
RT1101        1622           0      0.62873E+08
RT1102        1621        1622      0.46160E-02
VT1102        1620        1621 AC   0.00000E+00
LT1102        1619        1620      0.33871E-09
CT1103        1625           0      0.48472E-13
RT1103        1625           0      0.62873E+08
RT1104        1624        1625      0.46160E-02
VT1104        1623        1624 AC   0.00000E+00
LT1104        1622        1623      0.33871E-09
CT1105        1628           0      0.48472E-13
RT1105        1628           0      0.62873E+08
RT1106        1627        1628      0.46160E-02
VT1106        1626        1627 AC   0.00000E+00
LT1106        1625        1626      0.33871E-09
CT1107        1631           0      0.48472E-13
RT1107        1631           0      0.62873E+08
RT1108        1630        1631      0.46160E-02
VT1108        1629        1630 AC   0.00000E+00
LT1108        1628        1629      0.33871E-09
CT1109        1634           0      0.48472E-13
RT1109        1634           0      0.62873E+08
RT1110        1633        1634      0.46160E-02
VT1110        1632        1633 AC   0.00000E+00
LT1110        1631        1632      0.33871E-09
CT1111        1637           0      0.48472E-13
RT1111        1637           0      0.62873E+08
RT1112        1636        1637      0.46160E-02
VT1112        1635        1636 AC   0.00000E+00
LT1112        1634        1635      0.33871E-09
CT1113        1640           0      0.48472E-13
RT1113        1640           0      0.62873E+08
RT1114        1639        1640      0.46160E-02
VT1114        1638        1639 AC   0.00000E+00
LT1114        1637        1638      0.33871E-09
CT1115        1643           0      0.48472E-13
RT1115        1643           0      0.62873E+08
RT1116        1642        1643      0.46160E-02
VT1116        1641        1642 AC   0.00000E+00
LT1116        1640        1641      0.33871E-09
CT1117        1646           0      0.48472E-13
RT1117        1646           0      0.62873E+08
RT1118        1645        1646      0.46160E-02
VT1118        1644        1645 AC   0.00000E+00
LT1118        1643        1644      0.33871E-09
CT1119        1649           0      0.48472E-13
RT1119        1649           0      0.62873E+08
RT1120        1648        1649      0.46160E-02
VT1120        1647        1648 AC   0.00000E+00
LT1120        1646        1647      0.33871E-09
CT1121        1652           0      0.48472E-13
RT1121        1652           0      0.62873E+08
RT1122        1651        1652      0.46160E-02
VT1122        1650        1651 AC   0.00000E+00
LT1122        1649        1650      0.33871E-09
CT1123        1655           0      0.48472E-13
RT1123        1655           0      0.62873E+08
RT1124        1654        1655      0.46160E-02
VT1124        1653        1654 AC   0.00000E+00
LT1124        1652        1653      0.33871E-09
CT1125        1658           0      0.48472E-13
RT1125        1658           0      0.62873E+08
RT1126        1657        1658      0.46160E-02
VT1126        1656        1657 AC   0.00000E+00
LT1126        1655        1656      0.33871E-09
CT1127        1661           0      0.48472E-13
RT1127        1661           0      0.62873E+08
RT1128        1660        1661      0.46160E-02
VT1128        1659        1660 AC   0.00000E+00
LT1128        1658        1659      0.33871E-09
CT1129        1664           0      0.48472E-13
RT1129        1664           0      0.62873E+08
RT1130        1663        1664      0.46160E-02
VT1130        1662        1663 AC   0.00000E+00
LT1130        1661        1662      0.33871E-09
CT1131        1667           0      0.48472E-13
RT1131        1667           0      0.62873E+08
RT1132        1666        1667      0.46160E-02
VT1132        1665        1666 AC   0.00000E+00
LT1132        1664        1665      0.33871E-09
CT1133        1670           0      0.48472E-13
RT1133        1670           0      0.62873E+08
RT1134        1669        1670      0.46160E-02
VT1134        1668        1669 AC   0.00000E+00
LT1134        1667        1668      0.33871E-09
CT1135        1673           0      0.48472E-13
RT1135        1673           0      0.62873E+08
RT1136        1672        1673      0.46160E-02
VT1136        1671        1672 AC   0.00000E+00
LT1136        1670        1671      0.33871E-09
CT1137        1676           0      0.48472E-13
RT1137        1676           0      0.62873E+08
RT1138        1675        1676      0.46160E-02
VT1138        1674        1675 AC   0.00000E+00
LT1138        1673        1674      0.33871E-09
CT1139        1679           0      0.48472E-13
RT1139        1679           0      0.62873E+08
RT1140        1678        1679      0.46160E-02
VT1140        1677        1678 AC   0.00000E+00
LT1140        1676        1677      0.33871E-09
CT1141        1682           0      0.48472E-13
RT1141        1682           0      0.62873E+08
RT1142        1681        1682      0.46160E-02
VT1142        1680        1681 AC   0.00000E+00
LT1142        1679        1680      0.33871E-09
CT1143        1685           0      0.48472E-13
RT1143        1685           0      0.62873E+08
RT1144        1684        1685      0.46160E-02
VT1144        1683        1684 AC   0.00000E+00
LT1144        1682        1683      0.33871E-09
CT1145        1688           0      0.48472E-13
RT1145        1688           0      0.62873E+08
RT1146        1687        1688      0.46160E-02
VT1146        1686        1687 AC   0.00000E+00
LT1146        1685        1686      0.33871E-09
CT1147        1691           0      0.48472E-13
RT1147        1691           0      0.62873E+08
RT1148        1690        1691      0.46160E-02
VT1148        1689        1690 AC   0.00000E+00
LT1148        1688        1689      0.33871E-09
CT1149        1694           0      0.48472E-13
RT1149        1694           0      0.62873E+08
RT1150        1693        1694      0.46160E-02
VT1150        1692        1693 AC   0.00000E+00
LT1150        1691        1692      0.33871E-09
CT1151        1697           0      0.48472E-13
RT1151        1697           0      0.62873E+08
RT1152        1696        1697      0.46160E-02
VT1152        1695        1696 AC   0.00000E+00
LT1152        1694        1695      0.33871E-09
CT1153        1700           0      0.48472E-13
RT1153        1700           0      0.62873E+08
RT1154        1699        1700      0.46160E-02
VT1154        1698        1699 AC   0.00000E+00
LT1154        1697        1698      0.33871E-09
CT1155        1703           0      0.48472E-13
RT1155        1703           0      0.62873E+08
RT1156        1702        1703      0.46160E-02
VT1156        1701        1702 AC   0.00000E+00
LT1156        1700        1701      0.33871E-09
CT1157        1706           0      0.77839E-13
RT1157        1706           0      0.62873E+08
RT1158        1705        1706      0.46160E-02
VT1158        1704        1705 AC   0.00000E+00
LT1158        1703        1704      0.33871E-09
CT1159        1707           0      0.48472E-13
RT1159        1707           0      0.62873E+08
CT1160        1710           0      0.26987E-13
RT1160        1710           0      0.62873E+08
RT1161        1709        1710      0.46160E-02
VT1161        1708        1709 AC   0.00000E+00
LT1161        1707        1708      0.95753E-09
CT1162        1713           0      0.26987E-13
RT1162        1713           0      0.62873E+08
RT1163        1712        1713      0.46160E-02
VT1163        1711        1712 AC   0.00000E+00
LT1163        1710        1711      0.95753E-09
CT1164        1716           0      0.26987E-13
RT1164        1716           0      0.62873E+08
RT1165        1715        1716      0.46160E-02
VT1165        1714        1715 AC   0.00000E+00
LT1165        1713        1714      0.95753E-09
CT1166        1719           0      0.48472E-13
RT1166        1719           0      0.62873E+08
RT1167        1718        1719      0.46160E-02
VT1167        1717        1718 AC   0.00000E+00
LT1167        1716        1717      0.95753E-09
CT1168        1720           0      0.48472E-13
RT1168        1720           0      0.62873E+08
CT1169        1723           0      0.26987E-13
RT1169        1723           0      0.62873E+08
RT1170        1722        1723      0.46160E-02
VT1170        1721        1722 AC   0.00000E+00
LT1170        1720        1721      0.95753E-09
CT1171        1726           0      0.26987E-13
RT1171        1726           0      0.62873E+08
RT1172        1725        1726      0.46160E-02
VT1172        1724        1725 AC   0.00000E+00
LT1172        1723        1724      0.95753E-09
CT1173        1729           0      0.26987E-13
RT1173        1729           0      0.62873E+08
RT1174        1728        1729      0.46160E-02
VT1174        1727        1728 AC   0.00000E+00
LT1174        1726        1727      0.95753E-09
CT1175        1732           0      0.48472E-13
RT1175        1732           0      0.62873E+08
RT1176        1731        1732      0.46160E-02
VT1176        1730        1731 AC   0.00000E+00
LT1176        1729        1730      0.95753E-09
CT1177        1733           0      0.48472E-13
RT1177        1733           0      0.62873E+08
CT1178        1736           0      0.26987E-13
RT1178        1736           0      0.62873E+08
RT1179        1735        1736      0.46160E-02
VT1179        1734        1735 AC   0.00000E+00
LT1179        1733        1734      0.95753E-09
CT1180        1739           0      0.26987E-13
RT1180        1739           0      0.62873E+08
RT1181        1738        1739      0.46160E-02
VT1181        1737        1738 AC   0.00000E+00
LT1181        1736        1737      0.95753E-09
CT1182        1742           0      0.26987E-13
RT1182        1742           0      0.62873E+08
RT1183        1741        1742      0.46160E-02
VT1183        1740        1741 AC   0.00000E+00
LT1183        1739        1740      0.95753E-09
CT1184        1745           0      0.48472E-13
RT1184        1745           0      0.62873E+08
RT1185        1744        1745      0.46160E-02
VT1185        1743        1744 AC   0.00000E+00
LT1185        1742        1743      0.95753E-09
CT1186        1746           0      0.48472E-13
RT1186        1746           0      0.62873E+08
CT1187        1749           0      0.26987E-13
RT1187        1749           0      0.62873E+08
RT1188        1748        1749      0.46160E-02
VT1188        1747        1748 AC   0.00000E+00
LT1188        1746        1747      0.95753E-09
CT1189        1752           0      0.26987E-13
RT1189        1752           0      0.62873E+08
RT1190        1751        1752      0.46160E-02
VT1190        1750        1751 AC   0.00000E+00
LT1190        1749        1750      0.95753E-09
CT1191        1755           0      0.26987E-13
RT1191        1755           0      0.62873E+08
RT1192        1754        1755      0.46160E-02
VT1192        1753        1754 AC   0.00000E+00
LT1192        1752        1753      0.95753E-09
CT1193        1758           0      0.48472E-13
RT1193        1758           0      0.62873E+08
RT1194        1757        1758      0.46160E-02
VT1194        1756        1757 AC   0.00000E+00
LT1194        1755        1756      0.95753E-09
CT1195        1759           0      0.48472E-13
RT1195        1759           0      0.62873E+08
CT1196        1762           0      0.26987E-13
RT1196        1762           0      0.62873E+08
RT1197        1761        1762      0.46160E-02
VT1197        1760        1761 AC   0.00000E+00
LT1197        1759        1760      0.95753E-09
CT1198        1765           0      0.26987E-13
RT1198        1765           0      0.62873E+08
RT1199        1764        1765      0.46160E-02
VT1199        1763        1764 AC   0.00000E+00
LT1199        1762        1763      0.95753E-09
CT1200        1768           0      0.26987E-13
RT1200        1768           0      0.62873E+08
RT1201        1767        1768      0.46160E-02
VT1201        1766        1767 AC   0.00000E+00
LT1201        1765        1766      0.95753E-09
CT1202        1771           0      0.48472E-13
RT1202        1771           0      0.62873E+08
RT1203        1770        1771      0.46160E-02
VT1203        1769        1770 AC   0.00000E+00
LT1203        1768        1769      0.95753E-09
CT1204        1772           0      0.48472E-13
RT1204        1772           0      0.62873E+08
CT1205        1775           0      0.26987E-13
RT1205        1775           0      0.62873E+08
RT1206        1774        1775      0.46160E-02
VT1206        1773        1774 AC   0.00000E+00
LT1206        1772        1773      0.95753E-09
CT1207        1778           0      0.26987E-13
RT1207        1778           0      0.62873E+08
RT1208        1777        1778      0.46160E-02
VT1208        1776        1777 AC   0.00000E+00
LT1208        1775        1776      0.95753E-09
CT1209        1781           0      0.26987E-13
RT1209        1781           0      0.62873E+08
RT1210        1780        1781      0.46160E-02
VT1210        1779        1780 AC   0.00000E+00
LT1210        1778        1779      0.95753E-09
CT1211        1784           0      0.48472E-13
RT1211        1784           0      0.62873E+08
RT1212        1783        1784      0.46160E-02
VT1212        1782        1783 AC   0.00000E+00
LT1212        1781        1782      0.95753E-09
CT1213        1785           0      0.48472E-13
RT1213        1785           0      0.62873E+08
CT1214        1788           0      0.26987E-13
RT1214        1788           0      0.62873E+08
RT1215        1787        1788      0.46160E-02
VT1215        1786        1787 AC   0.00000E+00
LT1215        1785        1786      0.95753E-09
CT1216        1791           0      0.26987E-13
RT1216        1791           0      0.62873E+08
RT1217        1790        1791      0.46160E-02
VT1217        1789        1790 AC   0.00000E+00
LT1217        1788        1789      0.95753E-09
CT1218        1794           0      0.26987E-13
RT1218        1794           0      0.62873E+08
RT1219        1793        1794      0.46160E-02
VT1219        1792        1793 AC   0.00000E+00
LT1219        1791        1792      0.95753E-09
CT1220        1797           0      0.48472E-13
RT1220        1797           0      0.62873E+08
RT1221        1796        1797      0.46160E-02
VT1221        1795        1796 AC   0.00000E+00
LT1221        1794        1795      0.95753E-09
CT1222        1798           0      0.48472E-13
RT1222        1798           0      0.62873E+08
CT1223        1801           0      0.26987E-13
RT1223        1801           0      0.62873E+08
RT1224        1800        1801      0.46160E-02
VT1224        1799        1800 AC   0.00000E+00
LT1224        1798        1799      0.95753E-09
CT1225        1804           0      0.26987E-13
RT1225        1804           0      0.62873E+08
RT1226        1803        1804      0.46160E-02
VT1226        1802        1803 AC   0.00000E+00
LT1226        1801        1802      0.95753E-09
CT1227        1807           0      0.26987E-13
RT1227        1807           0      0.62873E+08
RT1228        1806        1807      0.46160E-02
VT1228        1805        1806 AC   0.00000E+00
LT1228        1804        1805      0.95753E-09
CT1229        1810           0      0.48472E-13
RT1229        1810           0      0.62873E+08
RT1230        1809        1810      0.46160E-02
VT1230        1808        1809 AC   0.00000E+00
LT1230        1807        1808      0.95753E-09
CT1231        1811           0      0.48472E-13
RT1231        1811           0      0.62873E+08
CT1232        1814           0      0.26987E-13
RT1232        1814           0      0.62873E+08
RT1233        1813        1814      0.46160E-02
VT1233        1812        1813 AC   0.00000E+00
LT1233        1811        1812      0.95753E-09
CT1234        1817           0      0.26987E-13
RT1234        1817           0      0.62873E+08
RT1235        1816        1817      0.46160E-02
VT1235        1815        1816 AC   0.00000E+00
LT1235        1814        1815      0.95753E-09
CT1236        1820           0      0.26987E-13
RT1236        1820           0      0.62873E+08
RT1237        1819        1820      0.46160E-02
VT1237        1818        1819 AC   0.00000E+00
LT1237        1817        1818      0.95753E-09
CT1238        1823           0      0.48472E-13
RT1238        1823           0      0.62873E+08
RT1239        1822        1823      0.46160E-02
VT1239        1821        1822 AC   0.00000E+00
LT1239        1820        1821      0.95753E-09
CT1240        1824           0      0.48472E-13
RT1240        1824           0      0.62873E+08
CT1241        1827           0      0.26987E-13
RT1241        1827           0      0.62873E+08
RT1242        1826        1827      0.46160E-02
VT1242        1825        1826 AC   0.00000E+00
LT1242        1824        1825      0.95753E-09
CT1243        1830           0      0.26987E-13
RT1243        1830           0      0.62873E+08
RT1244        1829        1830      0.46160E-02
VT1244        1828        1829 AC   0.00000E+00
LT1244        1827        1828      0.95753E-09
CT1245        1833           0      0.26987E-13
RT1245        1833           0      0.62873E+08
RT1246        1832        1833      0.46160E-02
VT1246        1831        1832 AC   0.00000E+00
LT1246        1830        1831      0.95753E-09
CT1247        1836           0      0.48472E-13
RT1247        1836           0      0.62873E+08
RT1248        1835        1836      0.46160E-02
VT1248        1834        1835 AC   0.00000E+00
LT1248        1833        1834      0.95753E-09
CT1249        1837           0      0.48472E-13
RT1249        1837           0      0.62873E+08
CT1250        1840           0      0.26987E-13
RT1250        1840           0      0.62873E+08
RT1251        1839        1840      0.46160E-02
VT1251        1838        1839 AC   0.00000E+00
LT1251        1837        1838      0.95753E-09
CT1252        1843           0      0.26987E-13
RT1252        1843           0      0.62873E+08
RT1253        1842        1843      0.46160E-02
VT1253        1841        1842 AC   0.00000E+00
LT1253        1840        1841      0.95753E-09
CT1254        1846           0      0.26987E-13
RT1254        1846           0      0.62873E+08
RT1255        1845        1846      0.46160E-02
VT1255        1844        1845 AC   0.00000E+00
LT1255        1843        1844      0.95753E-09
CT1256        1849           0      0.48472E-13
RT1256        1849           0      0.62873E+08
RT1257        1848        1849      0.46160E-02
VT1257        1847        1848 AC   0.00000E+00
LT1257        1846        1847      0.95753E-09
CT1258        1850           0      0.48472E-13
RT1258        1850           0      0.62873E+08
CT1259        1853           0      0.26987E-13
RT1259        1853           0      0.62873E+08
RT1260        1852        1853      0.46160E-02
VT1260        1851        1852 AC   0.00000E+00
LT1260        1850        1851      0.95753E-09
CT1261        1856           0      0.26987E-13
RT1261        1856           0      0.62873E+08
RT1262        1855        1856      0.46160E-02
VT1262        1854        1855 AC   0.00000E+00
LT1262        1853        1854      0.95753E-09
CT1263        1859           0      0.26987E-13
RT1263        1859           0      0.62873E+08
RT1264        1858        1859      0.46160E-02
VT1264        1857        1858 AC   0.00000E+00
LT1264        1856        1857      0.95753E-09
CT1265        1862           0      0.48472E-13
RT1265        1862           0      0.62873E+08
RT1266        1861        1862      0.46160E-02
VT1266        1860        1861 AC   0.00000E+00
LT1266        1859        1860      0.95753E-09
CT1267        1863           0      0.48472E-13
RT1267        1863           0      0.62873E+08
CT1268        1866           0      0.26987E-13
RT1268        1866           0      0.62873E+08
RT1269        1865        1866      0.46160E-02
VT1269        1864        1865 AC   0.00000E+00
LT1269        1863        1864      0.95753E-09
CT1270        1869           0      0.26987E-13
RT1270        1869           0      0.62873E+08
RT1271        1868        1869      0.46160E-02
VT1271        1867        1868 AC   0.00000E+00
LT1271        1866        1867      0.95753E-09
CT1272        1872           0      0.26987E-13
RT1272        1872           0      0.62873E+08
RT1273        1871        1872      0.46160E-02
VT1273        1870        1871 AC   0.00000E+00
LT1273        1869        1870      0.95753E-09
CT1274        1875           0      0.48472E-13
RT1274        1875           0      0.62873E+08
RT1275        1874        1875      0.46160E-02
VT1275        1873        1874 AC   0.00000E+00
LT1275        1872        1873      0.95753E-09
CT1276        1876           0      0.48472E-13
RT1276        1876           0      0.62873E+08
CT1277        1879           0      0.26987E-13
RT1277        1879           0      0.62873E+08
RT1278        1878        1879      0.46160E-02
VT1278        1877        1878 AC   0.00000E+00
LT1278        1876        1877      0.95753E-09
CT1279        1882           0      0.26987E-13
RT1279        1882           0      0.62873E+08
RT1280        1881        1882      0.46160E-02
VT1280        1880        1881 AC   0.00000E+00
LT1280        1879        1880      0.95753E-09
CT1281        1885           0      0.26987E-13
RT1281        1885           0      0.62873E+08
RT1282        1884        1885      0.46160E-02
VT1282        1883        1884 AC   0.00000E+00
LT1282        1882        1883      0.95753E-09
CT1283        1888           0      0.48472E-13
RT1283        1888           0      0.62873E+08
RT1284        1887        1888      0.46160E-02
VT1284        1886        1887 AC   0.00000E+00
LT1284        1885        1886      0.95753E-09
CT1285        1889           0      0.48472E-13
RT1285        1889           0      0.62873E+08
CT1286        1892           0      0.26987E-13
RT1286        1892           0      0.62873E+08
RT1287        1891        1892      0.46160E-02
VT1287        1890        1891 AC   0.00000E+00
LT1287        1889        1890      0.95753E-09
CT1288        1895           0      0.26987E-13
RT1288        1895           0      0.62873E+08
RT1289        1894        1895      0.46160E-02
VT1289        1893        1894 AC   0.00000E+00
LT1289        1892        1893      0.95753E-09
CT1290        1898           0      0.26987E-13
RT1290        1898           0      0.62873E+08
RT1291        1897        1898      0.46160E-02
VT1291        1896        1897 AC   0.00000E+00
LT1291        1895        1896      0.95753E-09
CT1292        1901           0      0.48472E-13
RT1292        1901           0      0.62873E+08
RT1293        1900        1901      0.46160E-02
VT1293        1899        1900 AC   0.00000E+00
LT1293        1898        1899      0.95753E-09
CT1294        1902           0      0.48472E-13
RT1294        1902           0      0.62873E+08
CT1295        1905           0      0.26987E-13
RT1295        1905           0      0.62873E+08
RT1296        1904        1905      0.46160E-02
VT1296        1903        1904 AC   0.00000E+00
LT1296        1902        1903      0.95753E-09
CT1297        1908           0      0.26987E-13
RT1297        1908           0      0.62873E+08
RT1298        1907        1908      0.46160E-02
VT1298        1906        1907 AC   0.00000E+00
LT1298        1905        1906      0.95753E-09
CT1299        1911           0      0.26987E-13
RT1299        1911           0      0.62873E+08
RT1300        1910        1911      0.46160E-02
VT1300        1909        1910 AC   0.00000E+00
LT1300        1908        1909      0.95753E-09
CT1301        1914           0      0.48472E-13
RT1301        1914           0      0.62873E+08
RT1302        1913        1914      0.46160E-02
VT1302        1912        1913 AC   0.00000E+00
LT1302        1911        1912      0.95753E-09
CT1303        1915           0      0.48472E-13
RT1303        1915           0      0.62873E+08
CT1304        1918           0      0.26987E-13
RT1304        1918           0      0.62873E+08
RT1305        1917        1918      0.46160E-02
VT1305        1916        1917 AC   0.00000E+00
LT1305        1915        1916      0.95753E-09
CT1306        1921           0      0.26987E-13
RT1306        1921           0      0.62873E+08
RT1307        1920        1921      0.46160E-02
VT1307        1919        1920 AC   0.00000E+00
LT1307        1918        1919      0.95753E-09
CT1308        1924           0      0.26987E-13
RT1308        1924           0      0.62873E+08
RT1309        1923        1924      0.46160E-02
VT1309        1922        1923 AC   0.00000E+00
LT1309        1921        1922      0.95753E-09
CT1310        1927           0      0.48472E-13
RT1310        1927           0      0.62873E+08
RT1311        1926        1927      0.46160E-02
VT1311        1925        1926 AC   0.00000E+00
LT1311        1924        1925      0.95753E-09
CT1312        1928           0      0.48472E-13
RT1312        1928           0      0.62873E+08
CT1313        1931           0      0.26987E-13
RT1313        1931           0      0.62873E+08
RT1314        1930        1931      0.46160E-02
VT1314        1929        1930 AC   0.00000E+00
LT1314        1928        1929      0.95753E-09
CT1315        1934           0      0.26987E-13
RT1315        1934           0      0.62873E+08
RT1316        1933        1934      0.46160E-02
VT1316        1932        1933 AC   0.00000E+00
LT1316        1931        1932      0.95753E-09
CT1317        1937           0      0.26987E-13
RT1317        1937           0      0.62873E+08
RT1318        1936        1937      0.46160E-02
VT1318        1935        1936 AC   0.00000E+00
LT1318        1934        1935      0.95753E-09
CT1319        1940           0      0.48472E-13
RT1319        1940           0      0.62873E+08
RT1320        1939        1940      0.46160E-02
VT1320        1938        1939 AC   0.00000E+00
LT1320        1937        1938      0.95753E-09
CT1321        1941           0      0.48472E-13
RT1321        1941           0      0.62873E+08
CT1322        1944           0      0.26987E-13
RT1322        1944           0      0.62873E+08
RT1323        1943        1944      0.46160E-02
VT1323        1942        1943 AC   0.00000E+00
LT1323        1941        1942      0.95753E-09
CT1324        1947           0      0.26987E-13
RT1324        1947           0      0.62873E+08
RT1325        1946        1947      0.46160E-02
VT1325        1945        1946 AC   0.00000E+00
LT1325        1944        1945      0.95753E-09
CT1326        1950           0      0.26987E-13
RT1326        1950           0      0.62873E+08
RT1327        1949        1950      0.46160E-02
VT1327        1948        1949 AC   0.00000E+00
LT1327        1947        1948      0.95753E-09
CT1328        1953           0      0.48472E-13
RT1328        1953           0      0.62873E+08
RT1329        1952        1953      0.46160E-02
VT1329        1951        1952 AC   0.00000E+00
LT1329        1950        1951      0.95753E-09
CT1330        1954           0      0.48472E-13
RT1330        1954           0      0.62873E+08
CT1331        1957           0      0.26987E-13
RT1331        1957           0      0.62873E+08
RT1332        1956        1957      0.46160E-02
VT1332        1955        1956 AC   0.00000E+00
LT1332        1954        1955      0.95753E-09
CT1333        1960           0      0.26987E-13
RT1333        1960           0      0.62873E+08
RT1334        1959        1960      0.46160E-02
VT1334        1958        1959 AC   0.00000E+00
LT1334        1957        1958      0.95753E-09
CT1335        1963           0      0.26987E-13
RT1335        1963           0      0.62873E+08
RT1336        1962        1963      0.46160E-02
VT1336        1961        1962 AC   0.00000E+00
LT1336        1960        1961      0.95753E-09
CT1337        1966           0      0.48472E-13
RT1337        1966           0      0.62873E+08
RT1338        1965        1966      0.46160E-02
VT1338        1964        1965 AC   0.00000E+00
LT1338        1963        1964      0.95753E-09
CT1339        1967           0      0.48472E-13
RT1339        1967           0      0.62873E+08
CT1340        1970           0      0.26987E-13
RT1340        1970           0      0.62873E+08
RT1341        1969        1970      0.46160E-02
VT1341        1968        1969 AC   0.00000E+00
LT1341        1967        1968      0.95753E-09
CT1342        1973           0      0.26987E-13
RT1342        1973           0      0.62873E+08
RT1343        1972        1973      0.46160E-02
VT1343        1971        1972 AC   0.00000E+00
LT1343        1970        1971      0.95753E-09
CT1344        1976           0      0.26987E-13
RT1344        1976           0      0.62873E+08
RT1345        1975        1976      0.46160E-02
VT1345        1974        1975 AC   0.00000E+00
LT1345        1973        1974      0.95753E-09
CT1346        1979           0      0.48472E-13
RT1346        1979           0      0.62873E+08
RT1347        1978        1979      0.46160E-02
VT1347        1977        1978 AC   0.00000E+00
LT1347        1976        1977      0.95753E-09
CT1348        1980           0      0.48472E-13
RT1348        1980           0      0.62873E+08
CT1349        1983           0      0.26987E-13
RT1349        1983           0      0.62873E+08
RT1350        1982        1983      0.46160E-02
VT1350        1981        1982 AC   0.00000E+00
LT1350        1980        1981      0.95753E-09
CT1351        1986           0      0.26987E-13
RT1351        1986           0      0.62873E+08
RT1352        1985        1986      0.46160E-02
VT1352        1984        1985 AC   0.00000E+00
LT1352        1983        1984      0.95753E-09
CT1353        1989           0      0.26987E-13
RT1353        1989           0      0.62873E+08
RT1354        1988        1989      0.46160E-02
VT1354        1987        1988 AC   0.00000E+00
LT1354        1986        1987      0.95753E-09
CT1355        1992           0      0.48472E-13
RT1355        1992           0      0.62873E+08
RT1356        1991        1992      0.46160E-02
VT1356        1990        1991 AC   0.00000E+00
LT1356        1989        1990      0.95753E-09
CT1357        1993           0      0.48472E-13
RT1357        1993           0      0.62873E+08
CT1358        1996           0      0.26987E-13
RT1358        1996           0      0.62873E+08
RT1359        1995        1996      0.46160E-02
VT1359        1994        1995 AC   0.00000E+00
LT1359        1993        1994      0.95753E-09
CT1360        1999           0      0.26987E-13
RT1360        1999           0      0.62873E+08
RT1361        1998        1999      0.46160E-02
VT1361        1997        1998 AC   0.00000E+00
LT1361        1996        1997      0.95753E-09
CT1362        2002           0      0.26987E-13
RT1362        2002           0      0.62873E+08
RT1363        2001        2002      0.46160E-02
VT1363        2000        2001 AC   0.00000E+00
LT1363        1999        2000      0.95753E-09
CT1364        2005           0      0.48472E-13
RT1364        2005           0      0.62873E+08
RT1365        2004        2005      0.46160E-02
VT1365        2003        2004 AC   0.00000E+00
LT1365        2002        2003      0.95753E-09
CT1366        2006           0      0.48472E-13
RT1366        2006           0      0.62873E+08
CT1367        2009           0      0.26987E-13
RT1367        2009           0      0.62873E+08
RT1368        2008        2009      0.46160E-02
VT1368        2007        2008 AC   0.00000E+00
LT1368        2006        2007      0.95753E-09
CT1369        2012           0      0.26987E-13
RT1369        2012           0      0.62873E+08
RT1370        2011        2012      0.46160E-02
VT1370        2010        2011 AC   0.00000E+00
LT1370        2009        2010      0.95753E-09
CT1371        2015           0      0.26987E-13
RT1371        2015           0      0.62873E+08
RT1372        2014        2015      0.46160E-02
VT1372        2013        2014 AC   0.00000E+00
LT1372        2012        2013      0.95753E-09
CT1373        2018           0      0.48472E-13
RT1373        2018           0      0.62873E+08
RT1374        2017        2018      0.46160E-02
VT1374        2016        2017 AC   0.00000E+00
LT1374        2015        2016      0.95753E-09
CT1375        2019           0      0.48472E-13
RT1375        2019           0      0.62873E+08
CT1376        2022           0      0.26987E-13
RT1376        2022           0      0.62873E+08
RT1377        2021        2022      0.46160E-02
VT1377        2020        2021 AC   0.00000E+00
LT1377        2019        2020      0.95753E-09
CT1378        2025           0      0.26987E-13
RT1378        2025           0      0.62873E+08
RT1379        2024        2025      0.46160E-02
VT1379        2023        2024 AC   0.00000E+00
LT1379        2022        2023      0.95753E-09
CT1380        2028           0      0.26987E-13
RT1380        2028           0      0.62873E+08
RT1381        2027        2028      0.46160E-02
VT1381        2026        2027 AC   0.00000E+00
LT1381        2025        2026      0.95753E-09
CT1382        2031           0      0.48472E-13
RT1382        2031           0      0.62873E+08
RT1383        2030        2031      0.46160E-02
VT1383        2029        2030 AC   0.00000E+00
LT1383        2028        2029      0.95753E-09
CT1384        2032           0      0.48472E-13
RT1384        2032           0      0.62873E+08
CT1385        2035           0      0.26987E-13
RT1385        2035           0      0.62873E+08
RT1386        2034        2035      0.46160E-02
VT1386        2033        2034 AC   0.00000E+00
LT1386        2032        2033      0.95753E-09
CT1387        2038           0      0.26987E-13
RT1387        2038           0      0.62873E+08
RT1388        2037        2038      0.46160E-02
VT1388        2036        2037 AC   0.00000E+00
LT1388        2035        2036      0.95753E-09
CT1389        2041           0      0.26987E-13
RT1389        2041           0      0.62873E+08
RT1390        2040        2041      0.46160E-02
VT1390        2039        2040 AC   0.00000E+00
LT1390        2038        2039      0.95753E-09
CT1391        2044           0      0.48472E-13
RT1391        2044           0      0.62873E+08
RT1392        2043        2044      0.46160E-02
VT1392        2042        2043 AC   0.00000E+00
LT1392        2041        2042      0.95753E-09
CT1393        2045           0      0.48472E-13
RT1393        2045           0      0.62873E+08
CT1394        2048           0      0.26987E-13
RT1394        2048           0      0.62873E+08
RT1395        2047        2048      0.46160E-02
VT1395        2046        2047 AC   0.00000E+00
LT1395        2045        2046      0.95753E-09
CT1396        2051           0      0.26987E-13
RT1396        2051           0      0.62873E+08
RT1397        2050        2051      0.46160E-02
VT1397        2049        2050 AC   0.00000E+00
LT1397        2048        2049      0.95753E-09
CT1398        2054           0      0.26987E-13
RT1398        2054           0      0.62873E+08
RT1399        2053        2054      0.46160E-02
VT1399        2052        2053 AC   0.00000E+00
LT1399        2051        2052      0.95753E-09
CT1400        2057           0      0.48472E-13
RT1400        2057           0      0.62873E+08
RT1401        2056        2057      0.46160E-02
VT1401        2055        2056 AC   0.00000E+00
LT1401        2054        2055      0.95753E-09
CT1402        2058           0      0.48472E-13
RT1402        2058           0      0.62873E+08
CT1403        2061           0      0.26987E-13
RT1403        2061           0      0.62873E+08
RT1404        2060        2061      0.46160E-02
VT1404        2059        2060 AC   0.00000E+00
LT1404        2058        2059      0.95753E-09
CT1405        2064           0      0.26987E-13
RT1405        2064           0      0.62873E+08
RT1406        2063        2064      0.46160E-02
VT1406        2062        2063 AC   0.00000E+00
LT1406        2061        2062      0.95753E-09
CT1407        2067           0      0.26987E-13
RT1407        2067           0      0.62873E+08
RT1408        2066        2067      0.46160E-02
VT1408        2065        2066 AC   0.00000E+00
LT1408        2064        2065      0.95753E-09
CT1409        2070           0      0.48472E-13
RT1409        2070           0      0.62873E+08
RT1410        2069        2070      0.46160E-02
VT1410        2068        2069 AC   0.00000E+00
LT1410        2067        2068      0.95753E-09
CT1411        2071           0      0.48472E-13
RT1411        2071           0      0.62873E+08
CT1412        2074           0      0.26987E-13
RT1412        2074           0      0.62873E+08
RT1413        2073        2074      0.46160E-02
VT1413        2072        2073 AC   0.00000E+00
LT1413        2071        2072      0.95753E-09
CT1414        2077           0      0.26987E-13
RT1414        2077           0      0.62873E+08
RT1415        2076        2077      0.46160E-02
VT1415        2075        2076 AC   0.00000E+00
LT1415        2074        2075      0.95753E-09
CT1416        2080           0      0.26987E-13
RT1416        2080           0      0.62873E+08
RT1417        2079        2080      0.46160E-02
VT1417        2078        2079 AC   0.00000E+00
LT1417        2077        2078      0.95753E-09
CT1418        2083           0      0.48472E-13
RT1418        2083           0      0.62873E+08
RT1419        2082        2083      0.46160E-02
VT1419        2081        2082 AC   0.00000E+00
LT1419        2080        2081      0.95753E-09
CT1420        2084           0      0.48472E-13
RT1420        2084           0      0.62873E+08
CT1421        2087           0      0.26987E-13
RT1421        2087           0      0.62873E+08
RT1422        2086        2087      0.46160E-02
VT1422        2085        2086 AC   0.00000E+00
LT1422        2084        2085      0.95753E-09
CT1423        2090           0      0.26987E-13
RT1423        2090           0      0.62873E+08
RT1424        2089        2090      0.46160E-02
VT1424        2088        2089 AC   0.00000E+00
LT1424        2087        2088      0.95753E-09
CT1425        2093           0      0.26987E-13
RT1425        2093           0      0.62873E+08
RT1426        2092        2093      0.46160E-02
VT1426        2091        2092 AC   0.00000E+00
LT1426        2090        2091      0.95753E-09
CT1427        2096           0      0.48472E-13
RT1427        2096           0      0.62873E+08
RT1428        2095        2096      0.46160E-02
VT1428        2094        2095 AC   0.00000E+00
LT1428        2093        2094      0.95753E-09
CT1429        2097           0      0.48472E-13
RT1429        2097           0      0.62873E+08
CT1430        2100           0      0.26987E-13
RT1430        2100           0      0.62873E+08
RT1431        2099        2100      0.46160E-02
VT1431        2098        2099 AC   0.00000E+00
LT1431        2097        2098      0.95753E-09
CT1432        2103           0      0.26987E-13
RT1432        2103           0      0.62873E+08
RT1433        2102        2103      0.46160E-02
VT1433        2101        2102 AC   0.00000E+00
LT1433        2100        2101      0.95753E-09
CT1434        2106           0      0.26987E-13
RT1434        2106           0      0.62873E+08
RT1435        2105        2106      0.46160E-02
VT1435        2104        2105 AC   0.00000E+00
LT1435        2103        2104      0.95753E-09
CT1436        2109           0      0.48472E-13
RT1436        2109           0      0.62873E+08
RT1437        2108        2109      0.46160E-02
VT1437        2107        2108 AC   0.00000E+00
LT1437        2106        2107      0.95753E-09
CT1438        2110           0      0.48472E-13
RT1438        2110           0      0.62873E+08
CT1439        2113           0      0.26987E-13
RT1439        2113           0      0.62873E+08
RT1440        2112        2113      0.46160E-02
VT1440        2111        2112 AC   0.00000E+00
LT1440        2110        2111      0.95753E-09
CT1441        2116           0      0.26987E-13
RT1441        2116           0      0.62873E+08
RT1442        2115        2116      0.46160E-02
VT1442        2114        2115 AC   0.00000E+00
LT1442        2113        2114      0.95753E-09
CT1443        2119           0      0.26987E-13
RT1443        2119           0      0.62873E+08
RT1444        2118        2119      0.46160E-02
VT1444        2117        2118 AC   0.00000E+00
LT1444        2116        2117      0.95753E-09
CT1445        2122           0      0.48472E-13
RT1445        2122           0      0.62873E+08
RT1446        2121        2122      0.46160E-02
VT1446        2120        2121 AC   0.00000E+00
LT1446        2119        2120      0.95753E-09
CT1447        2123           0      0.48472E-13
RT1447        2123           0      0.62873E+08
CT1448        2126           0      0.26987E-13
RT1448        2126           0      0.62873E+08
RT1449        2125        2126      0.46160E-02
VT1449        2124        2125 AC   0.00000E+00
LT1449        2123        2124      0.95753E-09
CT1450        2129           0      0.26987E-13
RT1450        2129           0      0.62873E+08
RT1451        2128        2129      0.46160E-02
VT1451        2127        2128 AC   0.00000E+00
LT1451        2126        2127      0.95753E-09
CT1452        2132           0      0.26987E-13
RT1452        2132           0      0.62873E+08
RT1453        2131        2132      0.46160E-02
VT1453        2130        2131 AC   0.00000E+00
LT1453        2129        2130      0.95753E-09
CT1454        2135           0      0.48472E-13
RT1454        2135           0      0.62873E+08
RT1455        2134        2135      0.46160E-02
VT1455        2133        2134 AC   0.00000E+00
LT1455        2132        2133      0.95753E-09
CT1456        2136           0      0.48472E-13
RT1456        2136           0      0.62873E+08
CT1457        2139           0      0.26987E-13
RT1457        2139           0      0.62873E+08
RT1458        2138        2139      0.46160E-02
VT1458        2137        2138 AC   0.00000E+00
LT1458        2136        2137      0.95753E-09
CT1459        2142           0      0.26987E-13
RT1459        2142           0      0.62873E+08
RT1460        2141        2142      0.46160E-02
VT1460        2140        2141 AC   0.00000E+00
LT1460        2139        2140      0.95753E-09
CT1461        2145           0      0.26987E-13
RT1461        2145           0      0.62873E+08
RT1462        2144        2145      0.46160E-02
VT1462        2143        2144 AC   0.00000E+00
LT1462        2142        2143      0.95753E-09
CT1463        2148           0      0.48472E-13
RT1463        2148           0      0.62873E+08
RT1464        2147        2148      0.46160E-02
VT1464        2146        2147 AC   0.00000E+00
LT1464        2145        2146      0.95753E-09
CT1465        2149           0      0.48472E-13
RT1465        2149           0      0.62873E+08
CT1466        2152           0      0.26987E-13
RT1466        2152           0      0.62873E+08
RT1467        2151        2152      0.46160E-02
VT1467        2150        2151 AC   0.00000E+00
LT1467        2149        2150      0.95753E-09
CT1468        2155           0      0.26987E-13
RT1468        2155           0      0.62873E+08
RT1469        2154        2155      0.46160E-02
VT1469        2153        2154 AC   0.00000E+00
LT1469        2152        2153      0.95753E-09
CT1470        2158           0      0.26987E-13
RT1470        2158           0      0.62873E+08
RT1471        2157        2158      0.46160E-02
VT1471        2156        2157 AC   0.00000E+00
LT1471        2155        2156      0.95753E-09
CT1472        2161           0      0.48472E-13
RT1472        2161           0      0.62873E+08
RT1473        2160        2161      0.46160E-02
VT1473        2159        2160 AC   0.00000E+00
LT1473        2158        2159      0.95753E-09
CT1474        2162           0      0.48472E-13
RT1474        2162           0      0.62873E+08
CT1475        2165           0      0.26987E-13
RT1475        2165           0      0.62873E+08
RT1476        2164        2165      0.46160E-02
VT1476        2163        2164 AC   0.00000E+00
LT1476        2162        2163      0.95753E-09
CT1477        2168           0      0.26987E-13
RT1477        2168           0      0.62873E+08
RT1478        2167        2168      0.46160E-02
VT1478        2166        2167 AC   0.00000E+00
LT1478        2165        2166      0.95753E-09
CT1479        2171           0      0.26987E-13
RT1479        2171           0      0.62873E+08
RT1480        2170        2171      0.46160E-02
VT1480        2169        2170 AC   0.00000E+00
LT1480        2168        2169      0.95753E-09
CT1481        2174           0      0.48472E-13
RT1481        2174           0      0.62873E+08
RT1482        2173        2174      0.46160E-02
VT1482        2172        2173 AC   0.00000E+00
LT1482        2171        2172      0.95753E-09
CT1483        2175           0      0.48472E-13
RT1483        2175           0      0.62873E+08
CT1484        2178           0      0.26987E-13
RT1484        2178           0      0.62873E+08
RT1485        2177        2178      0.46160E-02
VT1485        2176        2177 AC   0.00000E+00
LT1485        2175        2176      0.95753E-09
CT1486        2181           0      0.26987E-13
RT1486        2181           0      0.62873E+08
RT1487        2180        2181      0.46160E-02
VT1487        2179        2180 AC   0.00000E+00
LT1487        2178        2179      0.95753E-09
CT1488        2184           0      0.26987E-13
RT1488        2184           0      0.62873E+08
RT1489        2183        2184      0.46160E-02
VT1489        2182        2183 AC   0.00000E+00
LT1489        2181        2182      0.95753E-09
CT1490        2187           0      0.48472E-13
RT1490        2187           0      0.62873E+08
RT1491        2186        2187      0.46160E-02
VT1491        2185        2186 AC   0.00000E+00
LT1491        2184        2185      0.95753E-09
CT1492        2188           0      0.48472E-13
RT1492        2188           0      0.62873E+08
CT1493        2191           0      0.26987E-13
RT1493        2191           0      0.62873E+08
RT1494        2190        2191      0.46160E-02
VT1494        2189        2190 AC   0.00000E+00
LT1494        2188        2189      0.95753E-09
CT1495        2194           0      0.26987E-13
RT1495        2194           0      0.62873E+08
RT1496        2193        2194      0.46160E-02
VT1496        2192        2193 AC   0.00000E+00
LT1496        2191        2192      0.95753E-09
CT1497        2197           0      0.26987E-13
RT1497        2197           0      0.62873E+08
RT1498        2196        2197      0.46160E-02
VT1498        2195        2196 AC   0.00000E+00
LT1498        2194        2195      0.95753E-09
CT1499        2200           0      0.48472E-13
RT1499        2200           0      0.62873E+08
RT1500        2199        2200      0.46160E-02
VT1500        2198        2199 AC   0.00000E+00
LT1500        2197        2198      0.95753E-09
CT1501        2201           0      0.48472E-13
RT1501        2201           0      0.62873E+08
CT1502        2204           0      0.26987E-13
RT1502        2204           0      0.62873E+08
RT1503        2203        2204      0.46160E-02
VT1503        2202        2203 AC   0.00000E+00
LT1503        2201        2202      0.95753E-09
CT1504        2207           0      0.26987E-13
RT1504        2207           0      0.62873E+08
RT1505        2206        2207      0.46160E-02
VT1505        2205        2206 AC   0.00000E+00
LT1505        2204        2205      0.95753E-09
CT1506        2210           0      0.26987E-13
RT1506        2210           0      0.62873E+08
RT1507        2209        2210      0.46160E-02
VT1507        2208        2209 AC   0.00000E+00
LT1507        2207        2208      0.95753E-09
CT1508        2213           0      0.48472E-13
RT1508        2213           0      0.62873E+08
RT1509        2212        2213      0.46160E-02
VT1509        2211        2212 AC   0.00000E+00
LT1509        2210        2211      0.95753E-09
CT1510        2214           0      0.48472E-13
RT1510        2214           0      0.62873E+08
CT1511        2217           0      0.26987E-13
RT1511        2217           0      0.62873E+08
RT1512        2216        2217      0.46160E-02
VT1512        2215        2216 AC   0.00000E+00
LT1512        2214        2215      0.95753E-09
CT1513        2220           0      0.26987E-13
RT1513        2220           0      0.62873E+08
RT1514        2219        2220      0.46160E-02
VT1514        2218        2219 AC   0.00000E+00
LT1514        2217        2218      0.95753E-09
CT1515        2223           0      0.26987E-13
RT1515        2223           0      0.62873E+08
RT1516        2222        2223      0.46160E-02
VT1516        2221        2222 AC   0.00000E+00
LT1516        2220        2221      0.95753E-09
CT1517        2226           0      0.48472E-13
RT1517        2226           0      0.62873E+08
RT1518        2225        2226      0.46160E-02
VT1518        2224        2225 AC   0.00000E+00
LT1518        2223        2224      0.95753E-09
CT1519        2227           0      0.48472E-13
RT1519        2227           0      0.62873E+08
CT1520        2230           0      0.26987E-13
RT1520        2230           0      0.62873E+08
RT1521        2229        2230      0.46160E-02
VT1521        2228        2229 AC   0.00000E+00
LT1521        2227        2228      0.95753E-09
CT1522        2233           0      0.26987E-13
RT1522        2233           0      0.62873E+08
RT1523        2232        2233      0.46160E-02
VT1523        2231        2232 AC   0.00000E+00
LT1523        2230        2231      0.95753E-09
CT1524        2236           0      0.26987E-13
RT1524        2236           0      0.62873E+08
RT1525        2235        2236      0.46160E-02
VT1525        2234        2235 AC   0.00000E+00
LT1525        2233        2234      0.95753E-09
CT1526        2239           0      0.48472E-13
RT1526        2239           0      0.62873E+08
RT1527        2238        2239      0.46160E-02
VT1527        2237        2238 AC   0.00000E+00
LT1527        2236        2237      0.95753E-09
CT1528        2240           0      0.48472E-13
RT1528        2240           0      0.62873E+08
CT1529        2243           0      0.26987E-13
RT1529        2243           0      0.62873E+08
RT1530        2242        2243      0.46160E-02
VT1530        2241        2242 AC   0.00000E+00
LT1530        2240        2241      0.95753E-09
CT1531        2246           0      0.26987E-13
RT1531        2246           0      0.62873E+08
RT1532        2245        2246      0.46160E-02
VT1532        2244        2245 AC   0.00000E+00
LT1532        2243        2244      0.95753E-09
CT1533        2249           0      0.26987E-13
RT1533        2249           0      0.62873E+08
RT1534        2248        2249      0.46160E-02
VT1534        2247        2248 AC   0.00000E+00
LT1534        2246        2247      0.95753E-09
CT1535        2252           0      0.48472E-13
RT1535        2252           0      0.62873E+08
RT1536        2251        2252      0.46160E-02
VT1536        2250        2251 AC   0.00000E+00
LT1536        2249        2250      0.95753E-09
CT1537        2253           0      0.48472E-13
RT1537        2253           0      0.62873E+08
CT1538        2256           0      0.26987E-13
RT1538        2256           0      0.62873E+08
RT1539        2255        2256      0.46160E-02
VT1539        2254        2255 AC   0.00000E+00
LT1539        2253        2254      0.95753E-09
CT1540        2259           0      0.26987E-13
RT1540        2259           0      0.62873E+08
RT1541        2258        2259      0.46160E-02
VT1541        2257        2258 AC   0.00000E+00
LT1541        2256        2257      0.95753E-09
CT1542        2262           0      0.26987E-13
RT1542        2262           0      0.62873E+08
RT1543        2261        2262      0.46160E-02
VT1543        2260        2261 AC   0.00000E+00
LT1543        2259        2260      0.95753E-09
CT1544        2265           0      0.48472E-13
RT1544        2265           0      0.62873E+08
RT1545        2264        2265      0.46160E-02
VT1545        2263        2264 AC   0.00000E+00
LT1545        2262        2263      0.95753E-09
CT1546        2266           0      0.48472E-13
RT1546        2266           0      0.62873E+08
CT1547        2269           0      0.26987E-13
RT1547        2269           0      0.62873E+08
RT1548        2268        2269      0.46160E-02
VT1548        2267        2268 AC   0.00000E+00
LT1548        2266        2267      0.95753E-09
CT1549        2272           0      0.26987E-13
RT1549        2272           0      0.62873E+08
RT1550        2271        2272      0.46160E-02
VT1550        2270        2271 AC   0.00000E+00
LT1550        2269        2270      0.95753E-09
CT1551        2275           0      0.26987E-13
RT1551        2275           0      0.62873E+08
RT1552        2274        2275      0.46160E-02
VT1552        2273        2274 AC   0.00000E+00
LT1552        2272        2273      0.95753E-09
CT1553        2278           0      0.48472E-13
RT1553        2278           0      0.62873E+08
RT1554        2277        2278      0.46160E-02
VT1554        2276        2277 AC   0.00000E+00
LT1554        2275        2276      0.95753E-09
CT1555        2279           0      0.48472E-13
RT1555        2279           0      0.62873E+08
CT1556        2282           0      0.26987E-13
RT1556        2282           0      0.62873E+08
RT1557        2281        2282      0.46160E-02
VT1557        2280        2281 AC   0.00000E+00
LT1557        2279        2280      0.95753E-09
CT1558        2285           0      0.26987E-13
RT1558        2285           0      0.62873E+08
RT1559        2284        2285      0.46160E-02
VT1559        2283        2284 AC   0.00000E+00
LT1559        2282        2283      0.95753E-09
CT1560        2288           0      0.26987E-13
RT1560        2288           0      0.62873E+08
RT1561        2287        2288      0.46160E-02
VT1561        2286        2287 AC   0.00000E+00
LT1561        2285        2286      0.95753E-09
CT1562        2291           0      0.48472E-13
RT1562        2291           0      0.62873E+08
RT1563        2290        2291      0.46160E-02
VT1563        2289        2290 AC   0.00000E+00
LT1563        2288        2289      0.95753E-09
CT1564        2292           0      0.48472E-13
RT1564        2292           0      0.62873E+08
CT1565        2295           0      0.26987E-13
RT1565        2295           0      0.62873E+08
RT1566        2294        2295      0.46160E-02
VT1566        2293        2294 AC   0.00000E+00
LT1566        2292        2293      0.95753E-09
CT1567        2298           0      0.26987E-13
RT1567        2298           0      0.62873E+08
RT1568        2297        2298      0.46160E-02
VT1568        2296        2297 AC   0.00000E+00
LT1568        2295        2296      0.95753E-09
CT1569        2301           0      0.26987E-13
RT1569        2301           0      0.62873E+08
RT1570        2300        2301      0.46160E-02
VT1570        2299        2300 AC   0.00000E+00
LT1570        2298        2299      0.95753E-09
CT1571        2304           0      0.48472E-13
RT1571        2304           0      0.62873E+08
RT1572        2303        2304      0.46160E-02
VT1572        2302        2303 AC   0.00000E+00
LT1572        2301        2302      0.95753E-09
CT1573        2305           0      0.48472E-13
RT1573        2305           0      0.62873E+08
CT1574        2308           0      0.26987E-13
RT1574        2308           0      0.62873E+08
RT1575        2307        2308      0.46160E-02
VT1575        2306        2307 AC   0.00000E+00
LT1575        2305        2306      0.95753E-09
CT1576        2311           0      0.26987E-13
RT1576        2311           0      0.62873E+08
RT1577        2310        2311      0.46160E-02
VT1577        2309        2310 AC   0.00000E+00
LT1577        2308        2309      0.95753E-09
CT1578        2314           0      0.26987E-13
RT1578        2314           0      0.62873E+08
RT1579        2313        2314      0.46160E-02
VT1579        2312        2313 AC   0.00000E+00
LT1579        2311        2312      0.95753E-09
CT1580        2317           0      0.48472E-13
RT1580        2317           0      0.62873E+08
RT1581        2316        2317      0.46160E-02
VT1581        2315        2316 AC   0.00000E+00
LT1581        2314        2315      0.95753E-09
CT1582        2318           0      0.48472E-13
RT1582        2318           0      0.62873E+08
CT1583        2321           0      0.26987E-13
RT1583        2321           0      0.62873E+08
RT1584        2320        2321      0.46160E-02
VT1584        2319        2320 AC   0.00000E+00
LT1584        2318        2319      0.95753E-09
CT1585        2324           0      0.26987E-13
RT1585        2324           0      0.62873E+08
RT1586        2323        2324      0.46160E-02
VT1586        2322        2323 AC   0.00000E+00
LT1586        2321        2322      0.95753E-09
CT1587        2327           0      0.26987E-13
RT1587        2327           0      0.62873E+08
RT1588        2326        2327      0.46160E-02
VT1588        2325        2326 AC   0.00000E+00
LT1588        2324        2325      0.95753E-09
CT1589        2330           0      0.48472E-13
RT1589        2330           0      0.62873E+08
RT1590        2329        2330      0.46160E-02
VT1590        2328        2329 AC   0.00000E+00
LT1590        2327        2328      0.95753E-09
CT1591        2331           0      0.48472E-13
RT1591        2331           0      0.62873E+08
CT1592        2334           0      0.26987E-13
RT1592        2334           0      0.62873E+08
RT1593        2333        2334      0.46160E-02
VT1593        2332        2333 AC   0.00000E+00
LT1593        2331        2332      0.95753E-09
CT1594        2337           0      0.26987E-13
RT1594        2337           0      0.62873E+08
RT1595        2336        2337      0.46160E-02
VT1595        2335        2336 AC   0.00000E+00
LT1595        2334        2335      0.95753E-09
CT1596        2340           0      0.26987E-13
RT1596        2340           0      0.62873E+08
RT1597        2339        2340      0.46160E-02
VT1597        2338        2339 AC   0.00000E+00
LT1597        2337        2338      0.95753E-09
CT1598        2343           0      0.48472E-13
RT1598        2343           0      0.62873E+08
RT1599        2342        2343      0.46160E-02
VT1599        2341        2342 AC   0.00000E+00
LT1599        2340        2341      0.95753E-09
CT1600        2344           0      0.48472E-13
RT1600        2344           0      0.62873E+08
CT1601        2347           0      0.26987E-13
RT1601        2347           0      0.62873E+08
RT1602        2346        2347      0.46160E-02
VT1602        2345        2346 AC   0.00000E+00
LT1602        2344        2345      0.95753E-09
CT1603        2350           0      0.26987E-13
RT1603        2350           0      0.62873E+08
RT1604        2349        2350      0.46160E-02
VT1604        2348        2349 AC   0.00000E+00
LT1604        2347        2348      0.95753E-09
CT1605        2353           0      0.26987E-13
RT1605        2353           0      0.62873E+08
RT1606        2352        2353      0.46160E-02
VT1606        2351        2352 AC   0.00000E+00
LT1606        2350        2351      0.95753E-09
CT1607        2356           0      0.48472E-13
RT1607        2356           0      0.62873E+08
RT1608        2355        2356      0.46160E-02
VT1608        2354        2355 AC   0.00000E+00
LT1608        2353        2354      0.95753E-09
CT1609        2357           0      0.48472E-13
RT1609        2357           0      0.62873E+08
CT1610        2360           0      0.26987E-13
RT1610        2360           0      0.62873E+08
RT1611        2359        2360      0.46160E-02
VT1611        2358        2359 AC   0.00000E+00
LT1611        2357        2358      0.95753E-09
CT1612        2363           0      0.26987E-13
RT1612        2363           0      0.62873E+08
RT1613        2362        2363      0.46160E-02
VT1613        2361        2362 AC   0.00000E+00
LT1613        2360        2361      0.95753E-09
CT1614        2366           0      0.26987E-13
RT1614        2366           0      0.62873E+08
RT1615        2365        2366      0.46160E-02
VT1615        2364        2365 AC   0.00000E+00
LT1615        2363        2364      0.95753E-09
CT1616        2369           0      0.48472E-13
RT1616        2369           0      0.62873E+08
RT1617        2368        2369      0.46160E-02
VT1617        2367        2368 AC   0.00000E+00
LT1617        2366        2367      0.95753E-09
CT1618        2370           0      0.48472E-13
RT1618        2370           0      0.62873E+08
CT1619        2373           0      0.26987E-13
RT1619        2373           0      0.62873E+08
RT1620        2372        2373      0.46160E-02
VT1620        2371        2372 AC   0.00000E+00
LT1620        2370        2371      0.95753E-09
CT1621        2376           0      0.26987E-13
RT1621        2376           0      0.62873E+08
RT1622        2375        2376      0.46160E-02
VT1622        2374        2375 AC   0.00000E+00
LT1622        2373        2374      0.95753E-09
CT1623        2379           0      0.26987E-13
RT1623        2379           0      0.62873E+08
RT1624        2378        2379      0.46160E-02
VT1624        2377        2378 AC   0.00000E+00
LT1624        2376        2377      0.95753E-09
CT1625        2382           0      0.48472E-13
RT1625        2382           0      0.62873E+08
RT1626        2381        2382      0.46160E-02
VT1626        2380        2381 AC   0.00000E+00
LT1626        2379        2380      0.95753E-09
CT1627        2383           0      0.48472E-13
RT1627        2383           0      0.62873E+08
CT1628        2386           0      0.26987E-13
RT1628        2386           0      0.62873E+08
RT1629        2385        2386      0.46160E-02
VT1629        2384        2385 AC   0.00000E+00
LT1629        2383        2384      0.95753E-09
CT1630        2389           0      0.26987E-13
RT1630        2389           0      0.62873E+08
RT1631        2388        2389      0.46160E-02
VT1631        2387        2388 AC   0.00000E+00
LT1631        2386        2387      0.95753E-09
CT1632        2392           0      0.26987E-13
RT1632        2392           0      0.62873E+08
RT1633        2391        2392      0.46160E-02
VT1633        2390        2391 AC   0.00000E+00
LT1633        2389        2390      0.95753E-09
CT1634        2395           0      0.48472E-13
RT1634        2395           0      0.62873E+08
RT1635        2394        2395      0.46160E-02
VT1635        2393        2394 AC   0.00000E+00
LT1635        2392        2393      0.95753E-09
CT1636        2396           0      0.48472E-13
RT1636        2396           0      0.62873E+08
CT1637        2399           0      0.26987E-13
RT1637        2399           0      0.62873E+08
RT1638        2398        2399      0.46160E-02
VT1638        2397        2398 AC   0.00000E+00
LT1638        2396        2397      0.95753E-09
CT1639        2402           0      0.26987E-13
RT1639        2402           0      0.62873E+08
RT1640        2401        2402      0.46160E-02
VT1640        2400        2401 AC   0.00000E+00
LT1640        2399        2400      0.95753E-09
CT1641        2405           0      0.26987E-13
RT1641        2405           0      0.62873E+08
RT1642        2404        2405      0.46160E-02
VT1642        2403        2404 AC   0.00000E+00
LT1642        2402        2403      0.95753E-09
CT1643        2408           0      0.48472E-13
RT1643        2408           0      0.62873E+08
RT1644        2407        2408      0.46160E-02
VT1644        2406        2407 AC   0.00000E+00
LT1644        2405        2406      0.95753E-09
CT1645        2409           0      0.48472E-13
RT1645        2409           0      0.62873E+08
CT1646        2412           0      0.26987E-13
RT1646        2412           0      0.62873E+08
RT1647        2411        2412      0.46160E-02
VT1647        2410        2411 AC   0.00000E+00
LT1647        2409        2410      0.95753E-09
CT1648        2415           0      0.26987E-13
RT1648        2415           0      0.62873E+08
RT1649        2414        2415      0.46160E-02
VT1649        2413        2414 AC   0.00000E+00
LT1649        2412        2413      0.95753E-09
CT1650        2418           0      0.26987E-13
RT1650        2418           0      0.62873E+08
RT1651        2417        2418      0.46160E-02
VT1651        2416        2417 AC   0.00000E+00
LT1651        2415        2416      0.95753E-09
CT1652        2421           0      0.48472E-13
RT1652        2421           0      0.62873E+08
RT1653        2420        2421      0.46160E-02
VT1653        2419        2420 AC   0.00000E+00
LT1653        2418        2419      0.95753E-09
CT1654        2422           0      0.48472E-13
RT1654        2422           0      0.62873E+08
CT1655        2425           0      0.26987E-13
RT1655        2425           0      0.62873E+08
RT1656        2424        2425      0.46160E-02
VT1656        2423        2424 AC   0.00000E+00
LT1656        2422        2423      0.95753E-09
CT1657        2428           0      0.26987E-13
RT1657        2428           0      0.62873E+08
RT1658        2427        2428      0.46160E-02
VT1658        2426        2427 AC   0.00000E+00
LT1658        2425        2426      0.95753E-09
CT1659        2431           0      0.26987E-13
RT1659        2431           0      0.62873E+08
RT1660        2430        2431      0.46160E-02
VT1660        2429        2430 AC   0.00000E+00
LT1660        2428        2429      0.95753E-09
CT1661        2434           0      0.48472E-13
RT1661        2434           0      0.62873E+08
RT1662        2433        2434      0.46160E-02
VT1662        2432        2433 AC   0.00000E+00
LT1662        2431        2432      0.95753E-09
CT1663        2435           0      0.48472E-13
RT1663        2435           0      0.62873E+08
CT1664        2438           0      0.26987E-13
RT1664        2438           0      0.62873E+08
RT1665        2437        2438      0.46160E-02
VT1665        2436        2437 AC   0.00000E+00
LT1665        2435        2436      0.95753E-09
CT1666        2441           0      0.26987E-13
RT1666        2441           0      0.62873E+08
RT1667        2440        2441      0.46160E-02
VT1667        2439        2440 AC   0.00000E+00
LT1667        2438        2439      0.95753E-09
CT1668        2444           0      0.26987E-13
RT1668        2444           0      0.62873E+08
RT1669        2443        2444      0.46160E-02
VT1669        2442        2443 AC   0.00000E+00
LT1669        2441        2442      0.95753E-09
CT1670        2447           0      0.48472E-13
RT1670        2447           0      0.62873E+08
RT1671        2446        2447      0.46160E-02
VT1671        2445        2446 AC   0.00000E+00
LT1671        2444        2445      0.95753E-09
CT1672        2448           0      0.82610E-13
RT1672        2448           0      0.62873E+08
CT1673        2451           0      0.61126E-13
RT1673        2451           0      0.62873E+08
RT1674        2450        2451      0.46160E-02
VT1674        2449        2450 AC   0.00000E+00
LT1674        2448        2449      0.22562E-09
CT1675        2454           0      0.61126E-13
RT1675        2454           0      0.62873E+08
RT1676        2453        2454      0.46160E-02
VT1676        2452        2453 AC   0.00000E+00
LT1676        2451        2452      0.22562E-09
CT1677        2457           0      0.61126E-13
RT1677        2457           0      0.62873E+08
RT1678        2456        2457      0.46160E-02
VT1678        2455        2456 AC   0.00000E+00
LT1678        2454        2455      0.22562E-09
CT1679        2460           0      0.82610E-13
RT1679        2460           0      0.62873E+08
RT1680        2459        2460      0.46160E-02
VT1680        2458        2459 AC   0.00000E+00
LT1680        2457        2458      0.22562E-09
RT1681        2462          14      0.46160E-02
VT1681        2461        2462 AC   0.00000E+00
LT1681           1        2461      0.33871E-09
RT1682        2464          17      0.46160E-02
VT1682        2463        2464 AC   0.00000E+00
LT1682           4        2463      0.95753E-09
RT1683        2466          20      0.46160E-02
VT1683        2465        2466 AC   0.00000E+00
LT1683           7        2465      0.95753E-09
RT1684        2468          23      0.46160E-02
VT1684        2467        2468 AC   0.00000E+00
LT1684          10        2467      0.95753E-09
RT1685        2470          26      0.46160E-02
VT1685        2469        2470 AC   0.00000E+00
LT1685          13        2469      0.33871E-09
RT1686        2472          27      0.46160E-02
VT1686        2471        2472 AC   0.00000E+00
LT1686          14        2471      0.33871E-09
RT1687        2474          30      0.46160E-02
VT1687        2473        2474 AC   0.00000E+00
LT1687          17        2473      0.95753E-09
RT1688        2476          33      0.46160E-02
VT1688        2475        2476 AC   0.00000E+00
LT1688          20        2475      0.95753E-09
RT1689        2478          36      0.46160E-02
VT1689        2477        2478 AC   0.00000E+00
LT1689          23        2477      0.95753E-09
RT1690        2480          39      0.46160E-02
VT1690        2479        2480 AC   0.00000E+00
LT1690          26        2479      0.33871E-09
RT1691        2482          40      0.46160E-02
VT1691        2481        2482 AC   0.00000E+00
LT1691          27        2481      0.33871E-09
RT1692        2484          43      0.46160E-02
VT1692        2483        2484 AC   0.00000E+00
LT1692          30        2483      0.95753E-09
RT1693        2486          46      0.46160E-02
VT1693        2485        2486 AC   0.00000E+00
LT1693          33        2485      0.95753E-09
RT1694        2488          49      0.46160E-02
VT1694        2487        2488 AC   0.00000E+00
LT1694          36        2487      0.95753E-09
RT1695        2490          52      0.46160E-02
VT1695        2489        2490 AC   0.00000E+00
LT1695          39        2489      0.33871E-09
RT1696        2492          53      0.46160E-02
VT1696        2491        2492 AC   0.00000E+00
LT1696          40        2491      0.33871E-09
RT1697        2494          56      0.46160E-02
VT1697        2493        2494 AC   0.00000E+00
LT1697          43        2493      0.95753E-09
RT1698        2496          59      0.46160E-02
VT1698        2495        2496 AC   0.00000E+00
LT1698          46        2495      0.95753E-09
RT1699        2498          62      0.46160E-02
VT1699        2497        2498 AC   0.00000E+00
LT1699          49        2497      0.95753E-09
RT1700        2500          65      0.46160E-02
VT1700        2499        2500 AC   0.00000E+00
LT1700          52        2499      0.33871E-09
RT1701        2502          66      0.46160E-02
VT1701        2501        2502 AC   0.00000E+00
LT1701          53        2501      0.33871E-09
RT1702        2504          69      0.46160E-02
VT1702        2503        2504 AC   0.00000E+00
LT1702          56        2503      0.95753E-09
RT1703        2506          72      0.46160E-02
VT1703        2505        2506 AC   0.00000E+00
LT1703          59        2505      0.95753E-09
RT1704        2508          75      0.46160E-02
VT1704        2507        2508 AC   0.00000E+00
LT1704          62        2507      0.95753E-09
RT1705        2510          78      0.46160E-02
VT1705        2509        2510 AC   0.00000E+00
LT1705          65        2509      0.33871E-09
RT1706        2512          79      0.46160E-02
VT1706        2511        2512 AC   0.00000E+00
LT1706          66        2511      0.33871E-09
RT1707        2514          82      0.46160E-02
VT1707        2513        2514 AC   0.00000E+00
LT1707          69        2513      0.95753E-09
RT1708        2516          85      0.46160E-02
VT1708        2515        2516 AC   0.00000E+00
LT1708          72        2515      0.95753E-09
RT1709        2518          88      0.46160E-02
VT1709        2517        2518 AC   0.00000E+00
LT1709          75        2517      0.95753E-09
RT1710        2520          91      0.46160E-02
VT1710        2519        2520 AC   0.00000E+00
LT1710          78        2519      0.33871E-09
RT1711        2522          92      0.46160E-02
VT1711        2521        2522 AC   0.00000E+00
LT1711          79        2521      0.33871E-09
RT1712        2524          95      0.46160E-02
VT1712        2523        2524 AC   0.00000E+00
LT1712          82        2523      0.95753E-09
RT1713        2526          98      0.46160E-02
VT1713        2525        2526 AC   0.00000E+00
LT1713          85        2525      0.95753E-09
RT1714        2528         101      0.46160E-02
VT1714        2527        2528 AC   0.00000E+00
LT1714          88        2527      0.95753E-09
RT1715        2530         104      0.46160E-02
VT1715        2529        2530 AC   0.00000E+00
LT1715          91        2529      0.33871E-09
RT1716        2532         105      0.46160E-02
VT1716        2531        2532 AC   0.00000E+00
LT1716          92        2531      0.33871E-09
RT1717        2534         108      0.46160E-02
VT1717        2533        2534 AC   0.00000E+00
LT1717          95        2533      0.95753E-09
RT1718        2536         111      0.46160E-02
VT1718        2535        2536 AC   0.00000E+00
LT1718          98        2535      0.95753E-09
RT1719        2538         114      0.46160E-02
VT1719        2537        2538 AC   0.00000E+00
LT1719         101        2537      0.95753E-09
RT1720        2540         117      0.46160E-02
VT1720        2539        2540 AC   0.00000E+00
LT1720         104        2539      0.33871E-09
RT1721        2542         118      0.46160E-02
VT1721        2541        2542 AC   0.00000E+00
LT1721         105        2541      0.33871E-09
RT1722        2544         121      0.46160E-02
VT1722        2543        2544 AC   0.00000E+00
LT1722         108        2543      0.95753E-09
RT1723        2546         124      0.46160E-02
VT1723        2545        2546 AC   0.00000E+00
LT1723         111        2545      0.95753E-09
RT1724        2548         127      0.46160E-02
VT1724        2547        2548 AC   0.00000E+00
LT1724         114        2547      0.95753E-09
RT1725        2550         130      0.46160E-02
VT1725        2549        2550 AC   0.00000E+00
LT1725         117        2549      0.33871E-09
RT1726        2552         131      0.46160E-02
VT1726        2551        2552 AC   0.00000E+00
LT1726         118        2551      0.33871E-09
RT1727        2554         134      0.46160E-02
VT1727        2553        2554 AC   0.00000E+00
LT1727         121        2553      0.95753E-09
RT1728        2556         137      0.46160E-02
VT1728        2555        2556 AC   0.00000E+00
LT1728         124        2555      0.95753E-09
RT1729        2558         140      0.46160E-02
VT1729        2557        2558 AC   0.00000E+00
LT1729         127        2557      0.95753E-09
RT1730        2560         143      0.46160E-02
VT1730        2559        2560 AC   0.00000E+00
LT1730         130        2559      0.33871E-09
RT1731        2562         144      0.46160E-02
VT1731        2561        2562 AC   0.00000E+00
LT1731         131        2561      0.33871E-09
RT1732        2564         147      0.46160E-02
VT1732        2563        2564 AC   0.00000E+00
LT1732         134        2563      0.95753E-09
RT1733        2566         150      0.46160E-02
VT1733        2565        2566 AC   0.00000E+00
LT1733         137        2565      0.95753E-09
RT1734        2568         153      0.46160E-02
VT1734        2567        2568 AC   0.00000E+00
LT1734         140        2567      0.95753E-09
RT1735        2570         156      0.46160E-02
VT1735        2569        2570 AC   0.00000E+00
LT1735         143        2569      0.33871E-09
RT1736        2572         157      0.46160E-02
VT1736        2571        2572 AC   0.00000E+00
LT1736         144        2571      0.33871E-09
RT1737        2574         160      0.46160E-02
VT1737        2573        2574 AC   0.00000E+00
LT1737         147        2573      0.95753E-09
RT1738        2576         163      0.46160E-02
VT1738        2575        2576 AC   0.00000E+00
LT1738         150        2575      0.95753E-09
RT1739        2578         166      0.46160E-02
VT1739        2577        2578 AC   0.00000E+00
LT1739         153        2577      0.95753E-09
RT1740        2580         169      0.46160E-02
VT1740        2579        2580 AC   0.00000E+00
LT1740         156        2579      0.33871E-09
RT1741        2582         170      0.46160E-02
VT1741        2581        2582 AC   0.00000E+00
LT1741         157        2581      0.33871E-09
RT1742        2584         173      0.46160E-02
VT1742        2583        2584 AC   0.00000E+00
LT1742         160        2583      0.95753E-09
RT1743        2586         176      0.46160E-02
VT1743        2585        2586 AC   0.00000E+00
LT1743         163        2585      0.95753E-09
RT1744        2588         179      0.46160E-02
VT1744        2587        2588 AC   0.00000E+00
LT1744         166        2587      0.95753E-09
RT1745        2590         182      0.46160E-02
VT1745        2589        2590 AC   0.00000E+00
LT1745         169        2589      0.33871E-09
RT1746        2592         183      0.46160E-02
VT1746        2591        2592 AC   0.00000E+00
LT1746         170        2591      0.33871E-09
RT1747        2594         186      0.46160E-02
VT1747        2593        2594 AC   0.00000E+00
LT1747         173        2593      0.95753E-09
RT1748        2596         189      0.46160E-02
VT1748        2595        2596 AC   0.00000E+00
LT1748         176        2595      0.95753E-09
RT1749        2598         192      0.46160E-02
VT1749        2597        2598 AC   0.00000E+00
LT1749         179        2597      0.95753E-09
RT1750        2600         195      0.46160E-02
VT1750        2599        2600 AC   0.00000E+00
LT1750         182        2599      0.33871E-09
RT1751        2602         196      0.46160E-02
VT1751        2601        2602 AC   0.00000E+00
LT1751         183        2601      0.33871E-09
RT1752        2604         199      0.46160E-02
VT1752        2603        2604 AC   0.00000E+00
LT1752         186        2603      0.95753E-09
RT1753        2606         202      0.46160E-02
VT1753        2605        2606 AC   0.00000E+00
LT1753         189        2605      0.95753E-09
RT1754        2608         205      0.46160E-02
VT1754        2607        2608 AC   0.00000E+00
LT1754         192        2607      0.95753E-09
RT1755        2610         208      0.46160E-02
VT1755        2609        2610 AC   0.00000E+00
LT1755         195        2609      0.33871E-09
RT1756        2612         209      0.46160E-02
VT1756        2611        2612 AC   0.00000E+00
LT1756         196        2611      0.33871E-09
RT1757        2614         212      0.46160E-02
VT1757        2613        2614 AC   0.00000E+00
LT1757         199        2613      0.95753E-09
RT1758        2616         215      0.46160E-02
VT1758        2615        2616 AC   0.00000E+00
LT1758         202        2615      0.95753E-09
RT1759        2618         218      0.46160E-02
VT1759        2617        2618 AC   0.00000E+00
LT1759         205        2617      0.95753E-09
RT1760        2620         221      0.46160E-02
VT1760        2619        2620 AC   0.00000E+00
LT1760         208        2619      0.33871E-09
RT1761        2622         222      0.46160E-02
VT1761        2621        2622 AC   0.00000E+00
LT1761         209        2621      0.33871E-09
RT1762        2624         225      0.46160E-02
VT1762        2623        2624 AC   0.00000E+00
LT1762         212        2623      0.95753E-09
RT1763        2626         228      0.46160E-02
VT1763        2625        2626 AC   0.00000E+00
LT1763         215        2625      0.95753E-09
RT1764        2628         231      0.46160E-02
VT1764        2627        2628 AC   0.00000E+00
LT1764         218        2627      0.95753E-09
RT1765        2630         234      0.46160E-02
VT1765        2629        2630 AC   0.00000E+00
LT1765         221        2629      0.33871E-09
RT1766        2632         235      0.46160E-02
VT1766        2631        2632 AC   0.00000E+00
LT1766         222        2631      0.33871E-09
RT1767        2634         238      0.46160E-02
VT1767        2633        2634 AC   0.00000E+00
LT1767         225        2633      0.95753E-09
RT1768        2636         241      0.46160E-02
VT1768        2635        2636 AC   0.00000E+00
LT1768         228        2635      0.95753E-09
RT1769        2638         244      0.46160E-02
VT1769        2637        2638 AC   0.00000E+00
LT1769         231        2637      0.95753E-09
RT1770        2640         247      0.46160E-02
VT1770        2639        2640 AC   0.00000E+00
LT1770         234        2639      0.33871E-09
RT1771        2642         248      0.46160E-02
VT1771        2641        2642 AC   0.00000E+00
LT1771         235        2641      0.33871E-09
RT1772        2644         251      0.46160E-02
VT1772        2643        2644 AC   0.00000E+00
LT1772         238        2643      0.95753E-09
RT1773        2646         254      0.46160E-02
VT1773        2645        2646 AC   0.00000E+00
LT1773         241        2645      0.95753E-09
RT1774        2648         257      0.46160E-02
VT1774        2647        2648 AC   0.00000E+00
LT1774         244        2647      0.95753E-09
RT1775        2650         260      0.46160E-02
VT1775        2649        2650 AC   0.00000E+00
LT1775         247        2649      0.33871E-09
RT1776        2652         261      0.46160E-02
VT1776        2651        2652 AC   0.00000E+00
LT1776         248        2651      0.33871E-09
RT1777        2654         264      0.46160E-02
VT1777        2653        2654 AC   0.00000E+00
LT1777         251        2653      0.95753E-09
RT1778        2656         267      0.46160E-02
VT1778        2655        2656 AC   0.00000E+00
LT1778         254        2655      0.95753E-09
RT1779        2658         270      0.46160E-02
VT1779        2657        2658 AC   0.00000E+00
LT1779         257        2657      0.95753E-09
RT1780        2660         273      0.46160E-02
VT1780        2659        2660 AC   0.00000E+00
LT1780         260        2659      0.33871E-09
RT1781        2662         274      0.46160E-02
VT1781        2661        2662 AC   0.00000E+00
LT1781         261        2661      0.33871E-09
RT1782        2664         277      0.46160E-02
VT1782        2663        2664 AC   0.00000E+00
LT1782         264        2663      0.95753E-09
RT1783        2666         280      0.46160E-02
VT1783        2665        2666 AC   0.00000E+00
LT1783         267        2665      0.95753E-09
RT1784        2668         283      0.46160E-02
VT1784        2667        2668 AC   0.00000E+00
LT1784         270        2667      0.95753E-09
RT1785        2670         286      0.46160E-02
VT1785        2669        2670 AC   0.00000E+00
LT1785         273        2669      0.33871E-09
RT1786        2672         287      0.46160E-02
VT1786        2671        2672 AC   0.00000E+00
LT1786         274        2671      0.33871E-09
RT1787        2674         290      0.46160E-02
VT1787        2673        2674 AC   0.00000E+00
LT1787         277        2673      0.95753E-09
RT1788        2676         293      0.46160E-02
VT1788        2675        2676 AC   0.00000E+00
LT1788         280        2675      0.95753E-09
RT1789        2678         296      0.46160E-02
VT1789        2677        2678 AC   0.00000E+00
LT1789         283        2677      0.95753E-09
RT1790        2680         299      0.46160E-02
VT1790        2679        2680 AC   0.00000E+00
LT1790         286        2679      0.33871E-09
RT1791        2682         300      0.46160E-02
VT1791        2681        2682 AC   0.00000E+00
LT1791         287        2681      0.33871E-09
RT1792        2684         303      0.46160E-02
VT1792        2683        2684 AC   0.00000E+00
LT1792         290        2683      0.95753E-09
RT1793        2686         306      0.46160E-02
VT1793        2685        2686 AC   0.00000E+00
LT1793         293        2685      0.95753E-09
RT1794        2688         309      0.46160E-02
VT1794        2687        2688 AC   0.00000E+00
LT1794         296        2687      0.95753E-09
RT1795        2690         312      0.46160E-02
VT1795        2689        2690 AC   0.00000E+00
LT1795         299        2689      0.33871E-09
RT1796        2692         313      0.46160E-02
VT1796        2691        2692 AC   0.00000E+00
LT1796         300        2691      0.33871E-09
RT1797        2694         316      0.46160E-02
VT1797        2693        2694 AC   0.00000E+00
LT1797         303        2693      0.95753E-09
RT1798        2696         319      0.46160E-02
VT1798        2695        2696 AC   0.00000E+00
LT1798         306        2695      0.95753E-09
RT1799        2698         322      0.46160E-02
VT1799        2697        2698 AC   0.00000E+00
LT1799         309        2697      0.95753E-09
RT1800        2700         325      0.46160E-02
VT1800        2699        2700 AC   0.00000E+00
LT1800         312        2699      0.33871E-09
RT1801        2702         326      0.46160E-02
VT1801        2701        2702 AC   0.00000E+00
LT1801         313        2701      0.33871E-09
RT1802        2704         329      0.46160E-02
VT1802        2703        2704 AC   0.00000E+00
LT1802         316        2703      0.95753E-09
RT1803        2706         332      0.46160E-02
VT1803        2705        2706 AC   0.00000E+00
LT1803         319        2705      0.95753E-09
RT1804        2708         335      0.46160E-02
VT1804        2707        2708 AC   0.00000E+00
LT1804         322        2707      0.95753E-09
RT1805        2710         338      0.46160E-02
VT1805        2709        2710 AC   0.00000E+00
LT1805         325        2709      0.33871E-09
RT1806        2712         339      0.46160E-02
VT1806        2711        2712 AC   0.00000E+00
LT1806         326        2711      0.33871E-09
RT1807        2714         342      0.46160E-02
VT1807        2713        2714 AC   0.00000E+00
LT1807         329        2713      0.95753E-09
RT1808        2716         345      0.46160E-02
VT1808        2715        2716 AC   0.00000E+00
LT1808         332        2715      0.95753E-09
RT1809        2718         348      0.46160E-02
VT1809        2717        2718 AC   0.00000E+00
LT1809         335        2717      0.95753E-09
RT1810        2720         351      0.46160E-02
VT1810        2719        2720 AC   0.00000E+00
LT1810         338        2719      0.33871E-09
RT1811        2722         352      0.46160E-02
VT1811        2721        2722 AC   0.00000E+00
LT1811         339        2721      0.33871E-09
RT1812        2724         355      0.46160E-02
VT1812        2723        2724 AC   0.00000E+00
LT1812         342        2723      0.95753E-09
RT1813        2726         358      0.46160E-02
VT1813        2725        2726 AC   0.00000E+00
LT1813         345        2725      0.95753E-09
RT1814        2728         361      0.46160E-02
VT1814        2727        2728 AC   0.00000E+00
LT1814         348        2727      0.95753E-09
RT1815        2730         364      0.46160E-02
VT1815        2729        2730 AC   0.00000E+00
LT1815         351        2729      0.33871E-09
RT1816        2732         365      0.46160E-02
VT1816        2731        2732 AC   0.00000E+00
LT1816         352        2731      0.33871E-09
RT1817        2734         368      0.46160E-02
VT1817        2733        2734 AC   0.00000E+00
LT1817         355        2733      0.95753E-09
RT1818        2736         371      0.46160E-02
VT1818        2735        2736 AC   0.00000E+00
LT1818         358        2735      0.95753E-09
RT1819        2738         374      0.46160E-02
VT1819        2737        2738 AC   0.00000E+00
LT1819         361        2737      0.95753E-09
RT1820        2740         377      0.46160E-02
VT1820        2739        2740 AC   0.00000E+00
LT1820         364        2739      0.33871E-09
RT1821        2742         378      0.46160E-02
VT1821        2741        2742 AC   0.00000E+00
LT1821         365        2741      0.33871E-09
RT1822        2744         381      0.46160E-02
VT1822        2743        2744 AC   0.00000E+00
LT1822         368        2743      0.95753E-09
RT1823        2746         384      0.46160E-02
VT1823        2745        2746 AC   0.00000E+00
LT1823         371        2745      0.95753E-09
RT1824        2748         387      0.46160E-02
VT1824        2747        2748 AC   0.00000E+00
LT1824         374        2747      0.95753E-09
RT1825        2750         390      0.46160E-02
VT1825        2749        2750 AC   0.00000E+00
LT1825         377        2749      0.33871E-09
RT1826        2752         391      0.46160E-02
VT1826        2751        2752 AC   0.00000E+00
LT1826         378        2751      0.33871E-09
RT1827        2754         394      0.46160E-02
VT1827        2753        2754 AC   0.00000E+00
LT1827         381        2753      0.95753E-09
RT1828        2756         397      0.46160E-02
VT1828        2755        2756 AC   0.00000E+00
LT1828         384        2755      0.95753E-09
RT1829        2758         400      0.46160E-02
VT1829        2757        2758 AC   0.00000E+00
LT1829         387        2757      0.95753E-09
RT1830        2760         403      0.46160E-02
VT1830        2759        2760 AC   0.00000E+00
LT1830         390        2759      0.33871E-09
RT1831        2762         404      0.46160E-02
VT1831        2761        2762 AC   0.00000E+00
LT1831         391        2761      0.33871E-09
RT1832        2764         407      0.46160E-02
VT1832        2763        2764 AC   0.00000E+00
LT1832         394        2763      0.95753E-09
RT1833        2766         410      0.46160E-02
VT1833        2765        2766 AC   0.00000E+00
LT1833         397        2765      0.95753E-09
RT1834        2768         413      0.46160E-02
VT1834        2767        2768 AC   0.00000E+00
LT1834         400        2767      0.95753E-09
RT1835        2770         416      0.46160E-02
VT1835        2769        2770 AC   0.00000E+00
LT1835         403        2769      0.33871E-09
RT1836        2772         417      0.46160E-02
VT1836        2771        2772 AC   0.00000E+00
LT1836         404        2771      0.33871E-09
RT1837        2774         420      0.46160E-02
VT1837        2773        2774 AC   0.00000E+00
LT1837         407        2773      0.95753E-09
RT1838        2776         423      0.46160E-02
VT1838        2775        2776 AC   0.00000E+00
LT1838         410        2775      0.95753E-09
RT1839        2778         426      0.46160E-02
VT1839        2777        2778 AC   0.00000E+00
LT1839         413        2777      0.95753E-09
RT1840        2780         429      0.46160E-02
VT1840        2779        2780 AC   0.00000E+00
LT1840         416        2779      0.33871E-09
RT1841        2782         430      0.46160E-02
VT1841        2781        2782 AC   0.00000E+00
LT1841         417        2781      0.33871E-09
RT1842        2784         433      0.46160E-02
VT1842        2783        2784 AC   0.00000E+00
LT1842         420        2783      0.95753E-09
RT1843        2786         436      0.46160E-02
VT1843        2785        2786 AC   0.00000E+00
LT1843         423        2785      0.95753E-09
RT1844        2788         439      0.46160E-02
VT1844        2787        2788 AC   0.00000E+00
LT1844         426        2787      0.95753E-09
RT1845        2790         442      0.46160E-02
VT1845        2789        2790 AC   0.00000E+00
LT1845         429        2789      0.33871E-09
RT1846        2792         443      0.46160E-02
VT1846        2791        2792 AC   0.00000E+00
LT1846         430        2791      0.33871E-09
RT1847        2794         446      0.46160E-02
VT1847        2793        2794 AC   0.00000E+00
LT1847         433        2793      0.95753E-09
RT1848        2796         449      0.46160E-02
VT1848        2795        2796 AC   0.00000E+00
LT1848         436        2795      0.95753E-09
RT1849        2798         452      0.46160E-02
VT1849        2797        2798 AC   0.00000E+00
LT1849         439        2797      0.95753E-09
RT1850        2800         455      0.46160E-02
VT1850        2799        2800 AC   0.00000E+00
LT1850         442        2799      0.33871E-09
RT1851        2802         456      0.46160E-02
VT1851        2801        2802 AC   0.00000E+00
LT1851         443        2801      0.33871E-09
RT1852        2804         459      0.46160E-02
VT1852        2803        2804 AC   0.00000E+00
LT1852         446        2803      0.95753E-09
RT1853        2806         462      0.46160E-02
VT1853        2805        2806 AC   0.00000E+00
LT1853         449        2805      0.95753E-09
RT1854        2808         465      0.46160E-02
VT1854        2807        2808 AC   0.00000E+00
LT1854         452        2807      0.95753E-09
RT1855        2810         468      0.46160E-02
VT1855        2809        2810 AC   0.00000E+00
LT1855         455        2809      0.33871E-09
RT1856        2812         469      0.46160E-02
VT1856        2811        2812 AC   0.00000E+00
LT1856         456        2811      0.33871E-09
RT1857        2814         472      0.46160E-02
VT1857        2813        2814 AC   0.00000E+00
LT1857         459        2813      0.95753E-09
RT1858        2816         475      0.46160E-02
VT1858        2815        2816 AC   0.00000E+00
LT1858         462        2815      0.95753E-09
RT1859        2818         478      0.46160E-02
VT1859        2817        2818 AC   0.00000E+00
LT1859         465        2817      0.95753E-09
RT1860        2820         481      0.46160E-02
VT1860        2819        2820 AC   0.00000E+00
LT1860         468        2819      0.33871E-09
RT1861        2822         482      0.46160E-02
VT1861        2821        2822 AC   0.00000E+00
LT1861         469        2821      0.33871E-09
RT1862        2824         485      0.46160E-02
VT1862        2823        2824 AC   0.00000E+00
LT1862         472        2823      0.95753E-09
RT1863        2826         488      0.46160E-02
VT1863        2825        2826 AC   0.00000E+00
LT1863         475        2825      0.95753E-09
RT1864        2828         491      0.46160E-02
VT1864        2827        2828 AC   0.00000E+00
LT1864         478        2827      0.95753E-09
RT1865        2830         494      0.46160E-02
VT1865        2829        2830 AC   0.00000E+00
LT1865         481        2829      0.33871E-09
RT1866        2832         495      0.46160E-02
VT1866        2831        2832 AC   0.00000E+00
LT1866         482        2831      0.33871E-09
RT1867        2834         498      0.46160E-02
VT1867        2833        2834 AC   0.00000E+00
LT1867         485        2833      0.95753E-09
RT1868        2836         501      0.46160E-02
VT1868        2835        2836 AC   0.00000E+00
LT1868         488        2835      0.95753E-09
RT1869        2838         504      0.46160E-02
VT1869        2837        2838 AC   0.00000E+00
LT1869         491        2837      0.95753E-09
RT1870        2840         507      0.46160E-02
VT1870        2839        2840 AC   0.00000E+00
LT1870         494        2839      0.33871E-09
RT1871        2842         508      0.46160E-02
VT1871        2841        2842 AC   0.00000E+00
LT1871         495        2841      0.33871E-09
RT1872        2844         511      0.46160E-02
VT1872        2843        2844 AC   0.00000E+00
LT1872         498        2843      0.95753E-09
RT1873        2846         514      0.46160E-02
VT1873        2845        2846 AC   0.00000E+00
LT1873         501        2845      0.95753E-09
RT1874        2848         517      0.46160E-02
VT1874        2847        2848 AC   0.00000E+00
LT1874         504        2847      0.95753E-09
RT1875        2850         520      0.46160E-02
VT1875        2849        2850 AC   0.00000E+00
LT1875         507        2849      0.33871E-09
RT1876        2852         521      0.46160E-02
VT1876        2851        2852 AC   0.00000E+00
LT1876         508        2851      0.33871E-09
RT1877        2854         524      0.46160E-02
VT1877        2853        2854 AC   0.00000E+00
LT1877         511        2853      0.95753E-09
RT1878        2856         527      0.46160E-02
VT1878        2855        2856 AC   0.00000E+00
LT1878         514        2855      0.95753E-09
RT1879        2858         530      0.46160E-02
VT1879        2857        2858 AC   0.00000E+00
LT1879         517        2857      0.95753E-09
RT1880        2860         533      0.46160E-02
VT1880        2859        2860 AC   0.00000E+00
LT1880         520        2859      0.33871E-09
RT1881        2862         534      0.46160E-02
VT1881        2861        2862 AC   0.00000E+00
LT1881         521        2861      0.33871E-09
RT1882        2864         537      0.46160E-02
VT1882        2863        2864 AC   0.00000E+00
LT1882         524        2863      0.95753E-09
RT1883        2866         540      0.46160E-02
VT1883        2865        2866 AC   0.00000E+00
LT1883         527        2865      0.95753E-09
RT1884        2868         543      0.46160E-02
VT1884        2867        2868 AC   0.00000E+00
LT1884         530        2867      0.95753E-09
RT1885        2870         546      0.46160E-02
VT1885        2869        2870 AC   0.00000E+00
LT1885         533        2869      0.33871E-09
RT1886        2872         547      0.46160E-02
VT1886        2871        2872 AC   0.00000E+00
LT1886         534        2871      0.33871E-09
RT1887        2874         550      0.46160E-02
VT1887        2873        2874 AC   0.00000E+00
LT1887         537        2873      0.95753E-09
RT1888        2876         553      0.46160E-02
VT1888        2875        2876 AC   0.00000E+00
LT1888         540        2875      0.95753E-09
RT1889        2878         556      0.46160E-02
VT1889        2877        2878 AC   0.00000E+00
LT1889         543        2877      0.95753E-09
RT1890        2880         559      0.46160E-02
VT1890        2879        2880 AC   0.00000E+00
LT1890         546        2879      0.33871E-09
RT1891        2882         560      0.46160E-02
VT1891        2881        2882 AC   0.00000E+00
LT1891         547        2881      0.33871E-09
RT1892        2884         563      0.46160E-02
VT1892        2883        2884 AC   0.00000E+00
LT1892         550        2883      0.95753E-09
RT1893        2886         566      0.46160E-02
VT1893        2885        2886 AC   0.00000E+00
LT1893         553        2885      0.95753E-09
RT1894        2888         569      0.46160E-02
VT1894        2887        2888 AC   0.00000E+00
LT1894         556        2887      0.95753E-09
RT1895        2890         572      0.46160E-02
VT1895        2889        2890 AC   0.00000E+00
LT1895         559        2889      0.33871E-09
RT1896        2892         573      0.46160E-02
VT1896        2891        2892 AC   0.00000E+00
LT1896         560        2891      0.33871E-09
RT1897        2894         576      0.46160E-02
VT1897        2893        2894 AC   0.00000E+00
LT1897         563        2893      0.95753E-09
RT1898        2896         579      0.46160E-02
VT1898        2895        2896 AC   0.00000E+00
LT1898         566        2895      0.95753E-09
RT1899        2898         582      0.46160E-02
VT1899        2897        2898 AC   0.00000E+00
LT1899         569        2897      0.95753E-09
RT1900        2900         585      0.46160E-02
VT1900        2899        2900 AC   0.00000E+00
LT1900         572        2899      0.33871E-09
RT1901        2902         586      0.46160E-02
VT1901        2901        2902 AC   0.00000E+00
LT1901         573        2901      0.33871E-09
RT1902        2904         589      0.46160E-02
VT1902        2903        2904 AC   0.00000E+00
LT1902         576        2903      0.95753E-09
RT1903        2906         592      0.46160E-02
VT1903        2905        2906 AC   0.00000E+00
LT1903         579        2905      0.95753E-09
RT1904        2908         595      0.46160E-02
VT1904        2907        2908 AC   0.00000E+00
LT1904         582        2907      0.95753E-09
RT1905        2910         598      0.46160E-02
VT1905        2909        2910 AC   0.00000E+00
LT1905         585        2909      0.33871E-09
RT1906        2912         599      0.46160E-02
VT1906        2911        2912 AC   0.00000E+00
LT1906         586        2911      0.33871E-09
RT1907        2914         602      0.46160E-02
VT1907        2913        2914 AC   0.00000E+00
LT1907         589        2913      0.95753E-09
RT1908        2916         605      0.46160E-02
VT1908        2915        2916 AC   0.00000E+00
LT1908         592        2915      0.95753E-09
RT1909        2918         608      0.46160E-02
VT1909        2917        2918 AC   0.00000E+00
LT1909         595        2917      0.95753E-09
RT1910        2920         611      0.46160E-02
VT1910        2919        2920 AC   0.00000E+00
LT1910         598        2919      0.33871E-09
RT1911        2922         612      0.46160E-02
VT1911        2921        2922 AC   0.00000E+00
LT1911         599        2921      0.33871E-09
RT1912        2924         615      0.46160E-02
VT1912        2923        2924 AC   0.00000E+00
LT1912         602        2923      0.95753E-09
RT1913        2926         618      0.46160E-02
VT1913        2925        2926 AC   0.00000E+00
LT1913         605        2925      0.95753E-09
RT1914        2928         621      0.46160E-02
VT1914        2927        2928 AC   0.00000E+00
LT1914         608        2927      0.95753E-09
RT1915        2930         624      0.46160E-02
VT1915        2929        2930 AC   0.00000E+00
LT1915         611        2929      0.33871E-09
RT1916        2932         625      0.46160E-02
VT1916        2931        2932 AC   0.00000E+00
LT1916         612        2931      0.33871E-09
RT1917        2934         628      0.46160E-02
VT1917        2933        2934 AC   0.00000E+00
LT1917         615        2933      0.95753E-09
RT1918        2936         631      0.46160E-02
VT1918        2935        2936 AC   0.00000E+00
LT1918         618        2935      0.95753E-09
RT1919        2938         634      0.46160E-02
VT1919        2937        2938 AC   0.00000E+00
LT1919         621        2937      0.95753E-09
RT1920        2940         637      0.46160E-02
VT1920        2939        2940 AC   0.00000E+00
LT1920         624        2939      0.33871E-09
RT1921        2942         638      0.46160E-02
VT1921        2941        2942 AC   0.00000E+00
LT1921         625        2941      0.33871E-09
RT1922        2944         641      0.46160E-02
VT1922        2943        2944 AC   0.00000E+00
LT1922         628        2943      0.95753E-09
RT1923        2946         644      0.46160E-02
VT1923        2945        2946 AC   0.00000E+00
LT1923         631        2945      0.95753E-09
RT1924        2948         647      0.46160E-02
VT1924        2947        2948 AC   0.00000E+00
LT1924         634        2947      0.95753E-09
RT1925        2950         650      0.46160E-02
VT1925        2949        2950 AC   0.00000E+00
LT1925         637        2949      0.33871E-09
RT1926        2952         651      0.46160E-02
VT1926        2951        2952 AC   0.00000E+00
LT1926         638        2951      0.33871E-09
RT1927        2954         654      0.46160E-02
VT1927        2953        2954 AC   0.00000E+00
LT1927         641        2953      0.95753E-09
RT1928        2956         657      0.46160E-02
VT1928        2955        2956 AC   0.00000E+00
LT1928         644        2955      0.95753E-09
RT1929        2958         660      0.46160E-02
VT1929        2957        2958 AC   0.00000E+00
LT1929         647        2957      0.95753E-09
RT1930        2960         663      0.46160E-02
VT1930        2959        2960 AC   0.00000E+00
LT1930         650        2959      0.33871E-09
RT1931        2962         664      0.46160E-02
VT1931        2961        2962 AC   0.00000E+00
LT1931         651        2961      0.33871E-09
RT1932        2964         667      0.46160E-02
VT1932        2963        2964 AC   0.00000E+00
LT1932         654        2963      0.95753E-09
RT1933        2966         670      0.46160E-02
VT1933        2965        2966 AC   0.00000E+00
LT1933         657        2965      0.95753E-09
RT1934        2968         673      0.46160E-02
VT1934        2967        2968 AC   0.00000E+00
LT1934         660        2967      0.95753E-09
RT1935        2970         676      0.46160E-02
VT1935        2969        2970 AC   0.00000E+00
LT1935         663        2969      0.33871E-09
RT1936        2972         677      0.46160E-02
VT1936        2971        2972 AC   0.00000E+00
LT1936         664        2971      0.33871E-09
RT1937        2974         680      0.46160E-02
VT1937        2973        2974 AC   0.00000E+00
LT1937         667        2973      0.95753E-09
RT1938        2976         683      0.46160E-02
VT1938        2975        2976 AC   0.00000E+00
LT1938         670        2975      0.95753E-09
RT1939        2978         686      0.46160E-02
VT1939        2977        2978 AC   0.00000E+00
LT1939         673        2977      0.95753E-09
RT1940        2980         689      0.46160E-02
VT1940        2979        2980 AC   0.00000E+00
LT1940         676        2979      0.33871E-09
RT1941        2982         690      0.46160E-02
VT1941        2981        2982 AC   0.00000E+00
LT1941         677        2981      0.33871E-09
RT1942        2984         693      0.46160E-02
VT1942        2983        2984 AC   0.00000E+00
LT1942         680        2983      0.95753E-09
RT1943        2986         696      0.46160E-02
VT1943        2985        2986 AC   0.00000E+00
LT1943         683        2985      0.95753E-09
RT1944        2988         699      0.46160E-02
VT1944        2987        2988 AC   0.00000E+00
LT1944         686        2987      0.95753E-09
RT1945        2990         702      0.46160E-02
VT1945        2989        2990 AC   0.00000E+00
LT1945         689        2989      0.33871E-09
RT1946        2992         703      0.46160E-02
VT1946        2991        2992 AC   0.00000E+00
LT1946         690        2991      0.33871E-09
RT1947        2994         706      0.46160E-02
VT1947        2993        2994 AC   0.00000E+00
LT1947         693        2993      0.95753E-09
RT1948        2996         709      0.46160E-02
VT1948        2995        2996 AC   0.00000E+00
LT1948         696        2995      0.95753E-09
RT1949        2998         712      0.46160E-02
VT1949        2997        2998 AC   0.00000E+00
LT1949         699        2997      0.95753E-09
RT1950        3000         715      0.46160E-02
VT1950        2999        3000 AC   0.00000E+00
LT1950         702        2999      0.33871E-09
RT1951        3002         716      0.46160E-02
VT1951        3001        3002 AC   0.00000E+00
LT1951         703        3001      0.33871E-09
RT1952        3004         719      0.46160E-02
VT1952        3003        3004 AC   0.00000E+00
LT1952         706        3003      0.95753E-09
RT1953        3006         722      0.46160E-02
VT1953        3005        3006 AC   0.00000E+00
LT1953         709        3005      0.95753E-09
RT1954        3008         725      0.46160E-02
VT1954        3007        3008 AC   0.00000E+00
LT1954         712        3007      0.95753E-09
RT1955        3010         728      0.46160E-02
VT1955        3009        3010 AC   0.00000E+00
LT1955         715        3009      0.33871E-09
RT1956        3012         729      0.46160E-02
VT1956        3011        3012 AC   0.00000E+00
LT1956         716        3011      0.33871E-09
RT1957        3014         732      0.46160E-02
VT1957        3013        3014 AC   0.00000E+00
LT1957         719        3013      0.95753E-09
RT1958        3016         735      0.46160E-02
VT1958        3015        3016 AC   0.00000E+00
LT1958         722        3015      0.95753E-09
RT1959        3018         738      0.46160E-02
VT1959        3017        3018 AC   0.00000E+00
LT1959         725        3017      0.95753E-09
RT1960        3020         741      0.46160E-02
VT1960        3019        3020 AC   0.00000E+00
LT1960         728        3019      0.33871E-09
RT1961        3022         742      0.46160E-02
VT1961        3021        3022 AC   0.00000E+00
LT1961         729        3021      0.29070E-09
RT1962        3024         745      0.46160E-02
VT1962        3023        3024 AC   0.00000E+00
LT1962         732        3023      0.95753E-09
RT1963        3026         748      0.46160E-02
VT1963        3025        3026 AC   0.00000E+00
LT1963         735        3025      0.95753E-09
RT1964        3028         751      0.46160E-02
VT1964        3027        3028 AC   0.00000E+00
LT1964         738        3027      0.95753E-09
RT1965        3030         754      0.46160E-02
VT1965        3029        3030 AC   0.00000E+00
LT1965         741        3029      0.64812E-09
RT1966        3032         935      0.46160E-02
VT1966        3031        3032 AC   0.00000E+00
LT1966         742        3031      0.24269E-09
RT1967        3034         938      0.46160E-02
VT1967        3033        3034 AC   0.00000E+00
LT1967         745        3033      0.95753E-09
RT1968        3036         941      0.46160E-02
VT1968        3035        3036 AC   0.00000E+00
LT1968         748        3035      0.95753E-09
RT1969        3038         944      0.46160E-02
VT1969        3037        3038 AC   0.00000E+00
LT1969         751        3037      0.95753E-09
RT1970        3040         947      0.46160E-02
VT1970        3039        3040 AC   0.00000E+00
LT1970         754        3039      0.95753E-09
RT1971        3042         950      0.46160E-02
VT1971        3041        3042 AC   0.00000E+00
LT1971         757        3041      0.95753E-09
RT1972        3044         953      0.46160E-02
VT1972        3043        3044 AC   0.00000E+00
LT1972         760        3043      0.95753E-09
RT1973        3046         956      0.46160E-02
VT1973        3045        3046 AC   0.00000E+00
LT1973         763        3045      0.95753E-09
RT1974        3048         959      0.46160E-02
VT1974        3047        3048 AC   0.00000E+00
LT1974         766        3047      0.95753E-09
RT1975        3050         962      0.46160E-02
VT1975        3049        3050 AC   0.00000E+00
LT1975         769        3049      0.95753E-09
RT1976        3052         965      0.46160E-02
VT1976        3051        3052 AC   0.00000E+00
LT1976         772        3051      0.95753E-09
RT1977        3054         968      0.46160E-02
VT1977        3053        3054 AC   0.00000E+00
LT1977         775        3053      0.95753E-09
RT1978        3056         971      0.46160E-02
VT1978        3055        3056 AC   0.00000E+00
LT1978         778        3055      0.95753E-09
RT1979        3058         974      0.46160E-02
VT1979        3057        3058 AC   0.00000E+00
LT1979         781        3057      0.95753E-09
RT1980        3060         977      0.46160E-02
VT1980        3059        3060 AC   0.00000E+00
LT1980         784        3059      0.95753E-09
RT1981        3062         980      0.46160E-02
VT1981        3061        3062 AC   0.00000E+00
LT1981         787        3061      0.95753E-09
RT1982        3064         983      0.46160E-02
VT1982        3063        3064 AC   0.00000E+00
LT1982         790        3063      0.95753E-09
RT1983        3066         986      0.46160E-02
VT1983        3065        3066 AC   0.00000E+00
LT1983         793        3065      0.95753E-09
RT1984        3068         989      0.46160E-02
VT1984        3067        3068 AC   0.00000E+00
LT1984         796        3067      0.95753E-09
RT1985        3070         992      0.46160E-02
VT1985        3069        3070 AC   0.00000E+00
LT1985         799        3069      0.95753E-09
RT1986        3072         995      0.46160E-02
VT1986        3071        3072 AC   0.00000E+00
LT1986         802        3071      0.95753E-09
RT1987        3074         998      0.46160E-02
VT1987        3073        3074 AC   0.00000E+00
LT1987         805        3073      0.95753E-09
RT1988        3076        1001      0.46160E-02
VT1988        3075        3076 AC   0.00000E+00
LT1988         808        3075      0.95753E-09
RT1989        3078        1004      0.46160E-02
VT1989        3077        3078 AC   0.00000E+00
LT1989         811        3077      0.95753E-09
RT1990        3080        1007      0.46160E-02
VT1990        3079        3080 AC   0.00000E+00
LT1990         814        3079      0.95753E-09
RT1991        3082        1010      0.46160E-02
VT1991        3081        3082 AC   0.00000E+00
LT1991         817        3081      0.95753E-09
RT1992        3084        1013      0.46160E-02
VT1992        3083        3084 AC   0.00000E+00
LT1992         820        3083      0.95753E-09
RT1993        3086        1016      0.46160E-02
VT1993        3085        3086 AC   0.00000E+00
LT1993         823        3085      0.95753E-09
RT1994        3088        1019      0.46160E-02
VT1994        3087        3088 AC   0.00000E+00
LT1994         826        3087      0.95753E-09
RT1995        3090        1022      0.46160E-02
VT1995        3089        3090 AC   0.00000E+00
LT1995         829        3089      0.95753E-09
RT1996        3092        1025      0.46160E-02
VT1996        3091        3092 AC   0.00000E+00
LT1996         832        3091      0.95753E-09
RT1997        3094        1028      0.46160E-02
VT1997        3093        3094 AC   0.00000E+00
LT1997         835        3093      0.95753E-09
RT1998        3096        1031      0.46160E-02
VT1998        3095        3096 AC   0.00000E+00
LT1998         838        3095      0.95753E-09
RT1999        3098        1034      0.46160E-02
VT1999        3097        3098 AC   0.00000E+00
LT1999         841        3097      0.95753E-09
RT2000        3100        1037      0.46160E-02
VT2000        3099        3100 AC   0.00000E+00
LT2000         844        3099      0.95753E-09
RT2001        3102        1040      0.46160E-02
VT2001        3101        3102 AC   0.00000E+00
LT2001         847        3101      0.95753E-09
RT2002        3104        1043      0.46160E-02
VT2002        3103        3104 AC   0.00000E+00
LT2002         850        3103      0.95753E-09
RT2003        3106        1046      0.46160E-02
VT2003        3105        3106 AC   0.00000E+00
LT2003         853        3105      0.95753E-09
RT2004        3108        1049      0.46160E-02
VT2004        3107        3108 AC   0.00000E+00
LT2004         856        3107      0.95753E-09
RT2005        3110        1052      0.46160E-02
VT2005        3109        3110 AC   0.00000E+00
LT2005         859        3109      0.95753E-09
RT2006        3112        1055      0.46160E-02
VT2006        3111        3112 AC   0.00000E+00
LT2006         862        3111      0.95753E-09
RT2007        3114        1058      0.46160E-02
VT2007        3113        3114 AC   0.00000E+00
LT2007         865        3113      0.95753E-09
RT2008        3116        1061      0.46160E-02
VT2008        3115        3116 AC   0.00000E+00
LT2008         868        3115      0.95753E-09
RT2009        3118        1064      0.46160E-02
VT2009        3117        3118 AC   0.00000E+00
LT2009         871        3117      0.95753E-09
RT2010        3120        1067      0.46160E-02
VT2010        3119        3120 AC   0.00000E+00
LT2010         874        3119      0.95753E-09
RT2011        3122        1070      0.46160E-02
VT2011        3121        3122 AC   0.00000E+00
LT2011         877        3121      0.95753E-09
RT2012        3124        1073      0.46160E-02
VT2012        3123        3124 AC   0.00000E+00
LT2012         880        3123      0.95753E-09
RT2013        3126        1076      0.46160E-02
VT2013        3125        3126 AC   0.00000E+00
LT2013         883        3125      0.95753E-09
RT2014        3128        1079      0.46160E-02
VT2014        3127        3128 AC   0.00000E+00
LT2014         886        3127      0.95753E-09
RT2015        3130        1082      0.46160E-02
VT2015        3129        3130 AC   0.00000E+00
LT2015         889        3129      0.95753E-09
RT2016        3132        1085      0.46160E-02
VT2016        3131        3132 AC   0.00000E+00
LT2016         892        3131      0.95753E-09
RT2017        3134        1088      0.46160E-02
VT2017        3133        3134 AC   0.00000E+00
LT2017         895        3133      0.95753E-09
RT2018        3136        1091      0.46160E-02
VT2018        3135        3136 AC   0.00000E+00
LT2018         898        3135      0.95753E-09
RT2019        3138        1094      0.46160E-02
VT2019        3137        3138 AC   0.00000E+00
LT2019         901        3137      0.95753E-09
RT2020        3140        1097      0.46160E-02
VT2020        3139        3140 AC   0.00000E+00
LT2020         904        3139      0.95753E-09
RT2021        3142        1100      0.46160E-02
VT2021        3141        3142 AC   0.00000E+00
LT2021         907        3141      0.95753E-09
RT2022        3144        1103      0.46160E-02
VT2022        3143        3144 AC   0.00000E+00
LT2022         910        3143      0.95753E-09
RT2023        3146        1106      0.46160E-02
VT2023        3145        3146 AC   0.00000E+00
LT2023         913        3145      0.95753E-09
RT2024        3148        1109      0.46160E-02
VT2024        3147        3148 AC   0.00000E+00
LT2024         916        3147      0.95753E-09
RT2025        3150        1112      0.46160E-02
VT2025        3149        3150 AC   0.00000E+00
LT2025         919        3149      0.95753E-09
RT2026        3152        1115      0.46160E-02
VT2026        3151        3152 AC   0.00000E+00
LT2026         922        3151      0.95753E-09
RT2027        3154        1118      0.46160E-02
VT2027        3153        3154 AC   0.00000E+00
LT2027         925        3153      0.95753E-09
RT2028        3156        1121      0.46160E-02
VT2028        3155        3156 AC   0.00000E+00
LT2028         928        3155      0.95753E-09
RT2029        3158        1124      0.46160E-02
VT2029        3157        3158 AC   0.00000E+00
LT2029         931        3157      0.95753E-09
RT2030        3160        1127      0.46160E-02
VT2030        3159        3160 AC   0.00000E+00
LT2030         934        3159      0.24269E-09
RT2031        3162        1128      0.46160E-02
VT2031        3161        3162 AC   0.00000E+00
LT2031         935        3161      0.24269E-09
RT2032        3164        1131      0.46160E-02
VT2032        3163        3164 AC   0.00000E+00
LT2032         938        3163      0.95753E-09
RT2033        3166        1134      0.46160E-02
VT2033        3165        3166 AC   0.00000E+00
LT2033         941        3165      0.95753E-09
RT2034        3168        1137      0.46160E-02
VT2034        3167        3168 AC   0.00000E+00
LT2034         944        3167      0.95753E-09
RT2035        3170        1140      0.46160E-02
VT2035        3169        3170 AC   0.00000E+00
LT2035         947        3169      0.95753E-09
RT2036        3172        1143      0.46160E-02
VT2036        3171        3172 AC   0.00000E+00
LT2036         950        3171      0.95753E-09
RT2037        3174        1146      0.46160E-02
VT2037        3173        3174 AC   0.00000E+00
LT2037         953        3173      0.95753E-09
RT2038        3176        1149      0.46160E-02
VT2038        3175        3176 AC   0.00000E+00
LT2038         956        3175      0.95753E-09
RT2039        3178        1152      0.46160E-02
VT2039        3177        3178 AC   0.00000E+00
LT2039         959        3177      0.95753E-09
RT2040        3180        1155      0.46160E-02
VT2040        3179        3180 AC   0.00000E+00
LT2040         962        3179      0.95753E-09
RT2041        3182        1158      0.46160E-02
VT2041        3181        3182 AC   0.00000E+00
LT2041         965        3181      0.95753E-09
RT2042        3184        1161      0.46160E-02
VT2042        3183        3184 AC   0.00000E+00
LT2042         968        3183      0.95753E-09
RT2043        3186        1164      0.46160E-02
VT2043        3185        3186 AC   0.00000E+00
LT2043         971        3185      0.95753E-09
RT2044        3188        1167      0.46160E-02
VT2044        3187        3188 AC   0.00000E+00
LT2044         974        3187      0.95753E-09
RT2045        3190        1170      0.46160E-02
VT2045        3189        3190 AC   0.00000E+00
LT2045         977        3189      0.95753E-09
RT2046        3192        1173      0.46160E-02
VT2046        3191        3192 AC   0.00000E+00
LT2046         980        3191      0.95753E-09
RT2047        3194        1176      0.46160E-02
VT2047        3193        3194 AC   0.00000E+00
LT2047         983        3193      0.95753E-09
RT2048        3196        1179      0.46160E-02
VT2048        3195        3196 AC   0.00000E+00
LT2048         986        3195      0.95753E-09
RT2049        3198        1182      0.46160E-02
VT2049        3197        3198 AC   0.00000E+00
LT2049         989        3197      0.95753E-09
RT2050        3200        1185      0.46160E-02
VT2050        3199        3200 AC   0.00000E+00
LT2050         992        3199      0.95753E-09
RT2051        3202        1188      0.46160E-02
VT2051        3201        3202 AC   0.00000E+00
LT2051         995        3201      0.95753E-09
RT2052        3204        1191      0.46160E-02
VT2052        3203        3204 AC   0.00000E+00
LT2052         998        3203      0.95753E-09
RT2053        3206        1194      0.46160E-02
VT2053        3205        3206 AC   0.00000E+00
LT2053        1001        3205      0.95753E-09
RT2054        3208        1197      0.46160E-02
VT2054        3207        3208 AC   0.00000E+00
LT2054        1004        3207      0.95753E-09
RT2055        3210        1200      0.46160E-02
VT2055        3209        3210 AC   0.00000E+00
LT2055        1007        3209      0.95753E-09
RT2056        3212        1203      0.46160E-02
VT2056        3211        3212 AC   0.00000E+00
LT2056        1010        3211      0.95753E-09
RT2057        3214        1206      0.46160E-02
VT2057        3213        3214 AC   0.00000E+00
LT2057        1013        3213      0.95753E-09
RT2058        3216        1209      0.46160E-02
VT2058        3215        3216 AC   0.00000E+00
LT2058        1016        3215      0.95753E-09
RT2059        3218        1212      0.46160E-02
VT2059        3217        3218 AC   0.00000E+00
LT2059        1019        3217      0.95753E-09
RT2060        3220        1215      0.46160E-02
VT2060        3219        3220 AC   0.00000E+00
LT2060        1022        3219      0.95753E-09
RT2061        3222        1218      0.46160E-02
VT2061        3221        3222 AC   0.00000E+00
LT2061        1025        3221      0.95753E-09
RT2062        3224        1221      0.46160E-02
VT2062        3223        3224 AC   0.00000E+00
LT2062        1028        3223      0.95753E-09
RT2063        3226        1224      0.46160E-02
VT2063        3225        3226 AC   0.00000E+00
LT2063        1031        3225      0.95753E-09
RT2064        3228        1227      0.46160E-02
VT2064        3227        3228 AC   0.00000E+00
LT2064        1034        3227      0.95753E-09
RT2065        3230        1230      0.46160E-02
VT2065        3229        3230 AC   0.00000E+00
LT2065        1037        3229      0.95753E-09
RT2066        3232        1233      0.46160E-02
VT2066        3231        3232 AC   0.00000E+00
LT2066        1040        3231      0.95753E-09
RT2067        3234        1236      0.46160E-02
VT2067        3233        3234 AC   0.00000E+00
LT2067        1043        3233      0.95753E-09
RT2068        3236        1239      0.46160E-02
VT2068        3235        3236 AC   0.00000E+00
LT2068        1046        3235      0.95753E-09
RT2069        3238        1242      0.46160E-02
VT2069        3237        3238 AC   0.00000E+00
LT2069        1049        3237      0.95753E-09
RT2070        3240        1245      0.46160E-02
VT2070        3239        3240 AC   0.00000E+00
LT2070        1052        3239      0.95753E-09
RT2071        3242        1248      0.46160E-02
VT2071        3241        3242 AC   0.00000E+00
LT2071        1055        3241      0.95753E-09
RT2072        3244        1251      0.46160E-02
VT2072        3243        3244 AC   0.00000E+00
LT2072        1058        3243      0.95753E-09
RT2073        3246        1254      0.46160E-02
VT2073        3245        3246 AC   0.00000E+00
LT2073        1061        3245      0.95753E-09
RT2074        3248        1257      0.46160E-02
VT2074        3247        3248 AC   0.00000E+00
LT2074        1064        3247      0.95753E-09
RT2075        3250        1260      0.46160E-02
VT2075        3249        3250 AC   0.00000E+00
LT2075        1067        3249      0.95753E-09
RT2076        3252        1263      0.46160E-02
VT2076        3251        3252 AC   0.00000E+00
LT2076        1070        3251      0.95753E-09
RT2077        3254        1266      0.46160E-02
VT2077        3253        3254 AC   0.00000E+00
LT2077        1073        3253      0.95753E-09
RT2078        3256        1269      0.46160E-02
VT2078        3255        3256 AC   0.00000E+00
LT2078        1076        3255      0.95753E-09
RT2079        3258        1272      0.46160E-02
VT2079        3257        3258 AC   0.00000E+00
LT2079        1079        3257      0.95753E-09
RT2080        3260        1275      0.46160E-02
VT2080        3259        3260 AC   0.00000E+00
LT2080        1082        3259      0.95753E-09
RT2081        3262        1278      0.46160E-02
VT2081        3261        3262 AC   0.00000E+00
LT2081        1085        3261      0.95753E-09
RT2082        3264        1281      0.46160E-02
VT2082        3263        3264 AC   0.00000E+00
LT2082        1088        3263      0.95753E-09
RT2083        3266        1284      0.46160E-02
VT2083        3265        3266 AC   0.00000E+00
LT2083        1091        3265      0.95753E-09
RT2084        3268        1287      0.46160E-02
VT2084        3267        3268 AC   0.00000E+00
LT2084        1094        3267      0.95753E-09
RT2085        3270        1290      0.46160E-02
VT2085        3269        3270 AC   0.00000E+00
LT2085        1097        3269      0.95753E-09
RT2086        3272        1293      0.46160E-02
VT2086        3271        3272 AC   0.00000E+00
LT2086        1100        3271      0.95753E-09
RT2087        3274        1296      0.46160E-02
VT2087        3273        3274 AC   0.00000E+00
LT2087        1103        3273      0.95753E-09
RT2088        3276        1299      0.46160E-02
VT2088        3275        3276 AC   0.00000E+00
LT2088        1106        3275      0.95753E-09
RT2089        3278        1302      0.46160E-02
VT2089        3277        3278 AC   0.00000E+00
LT2089        1109        3277      0.95753E-09
RT2090        3280        1305      0.46160E-02
VT2090        3279        3280 AC   0.00000E+00
LT2090        1112        3279      0.95753E-09
RT2091        3282        1308      0.46160E-02
VT2091        3281        3282 AC   0.00000E+00
LT2091        1115        3281      0.95753E-09
RT2092        3284        1311      0.46160E-02
VT2092        3283        3284 AC   0.00000E+00
LT2092        1118        3283      0.95753E-09
RT2093        3286        1314      0.46160E-02
VT2093        3285        3286 AC   0.00000E+00
LT2093        1121        3285      0.95753E-09
RT2094        3288        1317      0.46160E-02
VT2094        3287        3288 AC   0.00000E+00
LT2094        1124        3287      0.95753E-09
RT2095        3290        1320      0.46160E-02
VT2095        3289        3290 AC   0.00000E+00
LT2095        1127        3289      0.24269E-09
RT2096        3292        1321      0.46160E-02
VT2096        3291        3292 AC   0.00000E+00
LT2096        1128        3291      0.24269E-09
RT2097        3294        1324      0.46160E-02
VT2097        3293        3294 AC   0.00000E+00
LT2097        1131        3293      0.95753E-09
RT2098        3296        1327      0.46160E-02
VT2098        3295        3296 AC   0.00000E+00
LT2098        1134        3295      0.95753E-09
RT2099        3298        1330      0.46160E-02
VT2099        3297        3298 AC   0.00000E+00
LT2099        1137        3297      0.95753E-09
RT2100        3300        1333      0.46160E-02
VT2100        3299        3300 AC   0.00000E+00
LT2100        1140        3299      0.95753E-09
RT2101        3302        1336      0.46160E-02
VT2101        3301        3302 AC   0.00000E+00
LT2101        1143        3301      0.95753E-09
RT2102        3304        1339      0.46160E-02
VT2102        3303        3304 AC   0.00000E+00
LT2102        1146        3303      0.95753E-09
RT2103        3306        1342      0.46160E-02
VT2103        3305        3306 AC   0.00000E+00
LT2103        1149        3305      0.95753E-09
RT2104        3308        1345      0.46160E-02
VT2104        3307        3308 AC   0.00000E+00
LT2104        1152        3307      0.95753E-09
RT2105        3310        1348      0.46160E-02
VT2105        3309        3310 AC   0.00000E+00
LT2105        1155        3309      0.95753E-09
RT2106        3312        1351      0.46160E-02
VT2106        3311        3312 AC   0.00000E+00
LT2106        1158        3311      0.95753E-09
RT2107        3314        1354      0.46160E-02
VT2107        3313        3314 AC   0.00000E+00
LT2107        1161        3313      0.95753E-09
RT2108        3316        1357      0.46160E-02
VT2108        3315        3316 AC   0.00000E+00
LT2108        1164        3315      0.95753E-09
RT2109        3318        1360      0.46160E-02
VT2109        3317        3318 AC   0.00000E+00
LT2109        1167        3317      0.95753E-09
RT2110        3320        1363      0.46160E-02
VT2110        3319        3320 AC   0.00000E+00
LT2110        1170        3319      0.95753E-09
RT2111        3322        1366      0.46160E-02
VT2111        3321        3322 AC   0.00000E+00
LT2111        1173        3321      0.95753E-09
RT2112        3324        1369      0.46160E-02
VT2112        3323        3324 AC   0.00000E+00
LT2112        1176        3323      0.95753E-09
RT2113        3326        1372      0.46160E-02
VT2113        3325        3326 AC   0.00000E+00
LT2113        1179        3325      0.95753E-09
RT2114        3328        1375      0.46160E-02
VT2114        3327        3328 AC   0.00000E+00
LT2114        1182        3327      0.95753E-09
RT2115        3330        1378      0.46160E-02
VT2115        3329        3330 AC   0.00000E+00
LT2115        1185        3329      0.95753E-09
RT2116        3332        1381      0.46160E-02
VT2116        3331        3332 AC   0.00000E+00
LT2116        1188        3331      0.95753E-09
RT2117        3334        1384      0.46160E-02
VT2117        3333        3334 AC   0.00000E+00
LT2117        1191        3333      0.95753E-09
RT2118        3336        1387      0.46160E-02
VT2118        3335        3336 AC   0.00000E+00
LT2118        1194        3335      0.95753E-09
RT2119        3338        1390      0.46160E-02
VT2119        3337        3338 AC   0.00000E+00
LT2119        1197        3337      0.95753E-09
RT2120        3340        1393      0.46160E-02
VT2120        3339        3340 AC   0.00000E+00
LT2120        1200        3339      0.95753E-09
RT2121        3342        1396      0.46160E-02
VT2121        3341        3342 AC   0.00000E+00
LT2121        1203        3341      0.95753E-09
RT2122        3344        1399      0.46160E-02
VT2122        3343        3344 AC   0.00000E+00
LT2122        1206        3343      0.95753E-09
RT2123        3346        1402      0.46160E-02
VT2123        3345        3346 AC   0.00000E+00
LT2123        1209        3345      0.95753E-09
RT2124        3348        1405      0.46160E-02
VT2124        3347        3348 AC   0.00000E+00
LT2124        1212        3347      0.95753E-09
RT2125        3350        1408      0.46160E-02
VT2125        3349        3350 AC   0.00000E+00
LT2125        1215        3349      0.95753E-09
RT2126        3352        1411      0.46160E-02
VT2126        3351        3352 AC   0.00000E+00
LT2126        1218        3351      0.95753E-09
RT2127        3354        1414      0.46160E-02
VT2127        3353        3354 AC   0.00000E+00
LT2127        1221        3353      0.95753E-09
RT2128        3356        1417      0.46160E-02
VT2128        3355        3356 AC   0.00000E+00
LT2128        1224        3355      0.95753E-09
RT2129        3358        1420      0.46160E-02
VT2129        3357        3358 AC   0.00000E+00
LT2129        1227        3357      0.95753E-09
RT2130        3360        1423      0.46160E-02
VT2130        3359        3360 AC   0.00000E+00
LT2130        1230        3359      0.95753E-09
RT2131        3362        1426      0.46160E-02
VT2131        3361        3362 AC   0.00000E+00
LT2131        1233        3361      0.95753E-09
RT2132        3364        1429      0.46160E-02
VT2132        3363        3364 AC   0.00000E+00
LT2132        1236        3363      0.95753E-09
RT2133        3366        1432      0.46160E-02
VT2133        3365        3366 AC   0.00000E+00
LT2133        1239        3365      0.95753E-09
RT2134        3368        1435      0.46160E-02
VT2134        3367        3368 AC   0.00000E+00
LT2134        1242        3367      0.95753E-09
RT2135        3370        1438      0.46160E-02
VT2135        3369        3370 AC   0.00000E+00
LT2135        1245        3369      0.95753E-09
RT2136        3372        1441      0.46160E-02
VT2136        3371        3372 AC   0.00000E+00
LT2136        1248        3371      0.95753E-09
RT2137        3374        1444      0.46160E-02
VT2137        3373        3374 AC   0.00000E+00
LT2137        1251        3373      0.95753E-09
RT2138        3376        1447      0.46160E-02
VT2138        3375        3376 AC   0.00000E+00
LT2138        1254        3375      0.95753E-09
RT2139        3378        1450      0.46160E-02
VT2139        3377        3378 AC   0.00000E+00
LT2139        1257        3377      0.95753E-09
RT2140        3380        1453      0.46160E-02
VT2140        3379        3380 AC   0.00000E+00
LT2140        1260        3379      0.95753E-09
RT2141        3382        1456      0.46160E-02
VT2141        3381        3382 AC   0.00000E+00
LT2141        1263        3381      0.95753E-09
RT2142        3384        1459      0.46160E-02
VT2142        3383        3384 AC   0.00000E+00
LT2142        1266        3383      0.95753E-09
RT2143        3386        1462      0.46160E-02
VT2143        3385        3386 AC   0.00000E+00
LT2143        1269        3385      0.95753E-09
RT2144        3388        1465      0.46160E-02
VT2144        3387        3388 AC   0.00000E+00
LT2144        1272        3387      0.95753E-09
RT2145        3390        1468      0.46160E-02
VT2145        3389        3390 AC   0.00000E+00
LT2145        1275        3389      0.95753E-09
RT2146        3392        1471      0.46160E-02
VT2146        3391        3392 AC   0.00000E+00
LT2146        1278        3391      0.95753E-09
RT2147        3394        1474      0.46160E-02
VT2147        3393        3394 AC   0.00000E+00
LT2147        1281        3393      0.95753E-09
RT2148        3396        1477      0.46160E-02
VT2148        3395        3396 AC   0.00000E+00
LT2148        1284        3395      0.95753E-09
RT2149        3398        1480      0.46160E-02
VT2149        3397        3398 AC   0.00000E+00
LT2149        1287        3397      0.95753E-09
RT2150        3400        1483      0.46160E-02
VT2150        3399        3400 AC   0.00000E+00
LT2150        1290        3399      0.95753E-09
RT2151        3402        1486      0.46160E-02
VT2151        3401        3402 AC   0.00000E+00
LT2151        1293        3401      0.95753E-09
RT2152        3404        1489      0.46160E-02
VT2152        3403        3404 AC   0.00000E+00
LT2152        1296        3403      0.95753E-09
RT2153        3406        1492      0.46160E-02
VT2153        3405        3406 AC   0.00000E+00
LT2153        1299        3405      0.95753E-09
RT2154        3408        1495      0.46160E-02
VT2154        3407        3408 AC   0.00000E+00
LT2154        1302        3407      0.95753E-09
RT2155        3410        1498      0.46160E-02
VT2155        3409        3410 AC   0.00000E+00
LT2155        1305        3409      0.95753E-09
RT2156        3412        1501      0.46160E-02
VT2156        3411        3412 AC   0.00000E+00
LT2156        1308        3411      0.95753E-09
RT2157        3414        1504      0.46160E-02
VT2157        3413        3414 AC   0.00000E+00
LT2157        1311        3413      0.95753E-09
RT2158        3416        1507      0.46160E-02
VT2158        3415        3416 AC   0.00000E+00
LT2158        1314        3415      0.95753E-09
RT2159        3418        1510      0.46160E-02
VT2159        3417        3418 AC   0.00000E+00
LT2159        1317        3417      0.95753E-09
RT2160        3420        1513      0.46160E-02
VT2160        3419        3420 AC   0.00000E+00
LT2160        1320        3419      0.24269E-09
RT2161        3422        1514      0.46160E-02
VT2161        3421        3422 AC   0.00000E+00
LT2161        1321        3421      0.24269E-09
RT2162        3424        1517      0.46160E-02
VT2162        3423        3424 AC   0.00000E+00
LT2162        1324        3423      0.95753E-09
RT2163        3426        1520      0.46160E-02
VT2163        3425        3426 AC   0.00000E+00
LT2163        1327        3425      0.95753E-09
RT2164        3428        1523      0.46160E-02
VT2164        3427        3428 AC   0.00000E+00
LT2164        1330        3427      0.95753E-09
RT2165        3430        1526      0.46160E-02
VT2165        3429        3430 AC   0.00000E+00
LT2165        1333        3429      0.95753E-09
RT2166        3432        1529      0.46160E-02
VT2166        3431        3432 AC   0.00000E+00
LT2166        1336        3431      0.95753E-09
RT2167        3434        1532      0.46160E-02
VT2167        3433        3434 AC   0.00000E+00
LT2167        1339        3433      0.95753E-09
RT2168        3436        1535      0.46160E-02
VT2168        3435        3436 AC   0.00000E+00
LT2168        1342        3435      0.95753E-09
RT2169        3438        1538      0.46160E-02
VT2169        3437        3438 AC   0.00000E+00
LT2169        1345        3437      0.95753E-09
RT2170        3440        1541      0.46160E-02
VT2170        3439        3440 AC   0.00000E+00
LT2170        1348        3439      0.95753E-09
RT2171        3442        1544      0.46160E-02
VT2171        3441        3442 AC   0.00000E+00
LT2171        1351        3441      0.95753E-09
RT2172        3444        1547      0.46160E-02
VT2172        3443        3444 AC   0.00000E+00
LT2172        1354        3443      0.95753E-09
RT2173        3446        1550      0.46160E-02
VT2173        3445        3446 AC   0.00000E+00
LT2173        1357        3445      0.95753E-09
RT2174        3448        1553      0.46160E-02
VT2174        3447        3448 AC   0.00000E+00
LT2174        1360        3447      0.95753E-09
RT2175        3450        1556      0.46160E-02
VT2175        3449        3450 AC   0.00000E+00
LT2175        1363        3449      0.95753E-09
RT2176        3452        1559      0.46160E-02
VT2176        3451        3452 AC   0.00000E+00
LT2176        1366        3451      0.95753E-09
RT2177        3454        1562      0.46160E-02
VT2177        3453        3454 AC   0.00000E+00
LT2177        1369        3453      0.95753E-09
RT2178        3456        1565      0.46160E-02
VT2178        3455        3456 AC   0.00000E+00
LT2178        1372        3455      0.95753E-09
RT2179        3458        1568      0.46160E-02
VT2179        3457        3458 AC   0.00000E+00
LT2179        1375        3457      0.95753E-09
RT2180        3460        1571      0.46160E-02
VT2180        3459        3460 AC   0.00000E+00
LT2180        1378        3459      0.95753E-09
RT2181        3462        1574      0.46160E-02
VT2181        3461        3462 AC   0.00000E+00
LT2181        1381        3461      0.95753E-09
RT2182        3464        1577      0.46160E-02
VT2182        3463        3464 AC   0.00000E+00
LT2182        1384        3463      0.95753E-09
RT2183        3466        1580      0.46160E-02
VT2183        3465        3466 AC   0.00000E+00
LT2183        1387        3465      0.95753E-09
RT2184        3468        1583      0.46160E-02
VT2184        3467        3468 AC   0.00000E+00
LT2184        1390        3467      0.95753E-09
RT2185        3470        1586      0.46160E-02
VT2185        3469        3470 AC   0.00000E+00
LT2185        1393        3469      0.95753E-09
RT2186        3472        1589      0.46160E-02
VT2186        3471        3472 AC   0.00000E+00
LT2186        1396        3471      0.95753E-09
RT2187        3474        1592      0.46160E-02
VT2187        3473        3474 AC   0.00000E+00
LT2187        1399        3473      0.95753E-09
RT2188        3476        1595      0.46160E-02
VT2188        3475        3476 AC   0.00000E+00
LT2188        1402        3475      0.95753E-09
RT2189        3478        1598      0.46160E-02
VT2189        3477        3478 AC   0.00000E+00
LT2189        1405        3477      0.95753E-09
RT2190        3480        1601      0.46160E-02
VT2190        3479        3480 AC   0.00000E+00
LT2190        1408        3479      0.95753E-09
RT2191        3482        1604      0.46160E-02
VT2191        3481        3482 AC   0.00000E+00
LT2191        1411        3481      0.95753E-09
RT2192        3484        1607      0.46160E-02
VT2192        3483        3484 AC   0.00000E+00
LT2192        1414        3483      0.95753E-09
RT2193        3486        1610      0.46160E-02
VT2193        3485        3486 AC   0.00000E+00
LT2193        1417        3485      0.95753E-09
RT2194        3488        1613      0.46160E-02
VT2194        3487        3488 AC   0.00000E+00
LT2194        1420        3487      0.95753E-09
RT2195        3490        1616      0.46160E-02
VT2195        3489        3490 AC   0.00000E+00
LT2195        1423        3489      0.95753E-09
RT2196        3492        1619      0.46160E-02
VT2196        3491        3492 AC   0.00000E+00
LT2196        1426        3491      0.95753E-09
RT2197        3494        1622      0.46160E-02
VT2197        3493        3494 AC   0.00000E+00
LT2197        1429        3493      0.95753E-09
RT2198        3496        1625      0.46160E-02
VT2198        3495        3496 AC   0.00000E+00
LT2198        1432        3495      0.95753E-09
RT2199        3498        1628      0.46160E-02
VT2199        3497        3498 AC   0.00000E+00
LT2199        1435        3497      0.95753E-09
RT2200        3500        1631      0.46160E-02
VT2200        3499        3500 AC   0.00000E+00
LT2200        1438        3499      0.95753E-09
RT2201        3502        1634      0.46160E-02
VT2201        3501        3502 AC   0.00000E+00
LT2201        1441        3501      0.95753E-09
RT2202        3504        1637      0.46160E-02
VT2202        3503        3504 AC   0.00000E+00
LT2202        1444        3503      0.95753E-09
RT2203        3506        1640      0.46160E-02
VT2203        3505        3506 AC   0.00000E+00
LT2203        1447        3505      0.95753E-09
RT2204        3508        1643      0.46160E-02
VT2204        3507        3508 AC   0.00000E+00
LT2204        1450        3507      0.95753E-09
RT2205        3510        1646      0.46160E-02
VT2205        3509        3510 AC   0.00000E+00
LT2205        1453        3509      0.95753E-09
RT2206        3512        1649      0.46160E-02
VT2206        3511        3512 AC   0.00000E+00
LT2206        1456        3511      0.95753E-09
RT2207        3514        1652      0.46160E-02
VT2207        3513        3514 AC   0.00000E+00
LT2207        1459        3513      0.95753E-09
RT2208        3516        1655      0.46160E-02
VT2208        3515        3516 AC   0.00000E+00
LT2208        1462        3515      0.95753E-09
RT2209        3518        1658      0.46160E-02
VT2209        3517        3518 AC   0.00000E+00
LT2209        1465        3517      0.95753E-09
RT2210        3520        1661      0.46160E-02
VT2210        3519        3520 AC   0.00000E+00
LT2210        1468        3519      0.95753E-09
RT2211        3522        1664      0.46160E-02
VT2211        3521        3522 AC   0.00000E+00
LT2211        1471        3521      0.95753E-09
RT2212        3524        1667      0.46160E-02
VT2212        3523        3524 AC   0.00000E+00
LT2212        1474        3523      0.95753E-09
RT2213        3526        1670      0.46160E-02
VT2213        3525        3526 AC   0.00000E+00
LT2213        1477        3525      0.95753E-09
RT2214        3528        1673      0.46160E-02
VT2214        3527        3528 AC   0.00000E+00
LT2214        1480        3527      0.95753E-09
RT2215        3530        1676      0.46160E-02
VT2215        3529        3530 AC   0.00000E+00
LT2215        1483        3529      0.95753E-09
RT2216        3532        1679      0.46160E-02
VT2216        3531        3532 AC   0.00000E+00
LT2216        1486        3531      0.95753E-09
RT2217        3534        1682      0.46160E-02
VT2217        3533        3534 AC   0.00000E+00
LT2217        1489        3533      0.95753E-09
RT2218        3536        1685      0.46160E-02
VT2218        3535        3536 AC   0.00000E+00
LT2218        1492        3535      0.95753E-09
RT2219        3538        1688      0.46160E-02
VT2219        3537        3538 AC   0.00000E+00
LT2219        1495        3537      0.95753E-09
RT2220        3540        1691      0.46160E-02
VT2220        3539        3540 AC   0.00000E+00
LT2220        1498        3539      0.95753E-09
RT2221        3542        1694      0.46160E-02
VT2221        3541        3542 AC   0.00000E+00
LT2221        1501        3541      0.95753E-09
RT2222        3544        1697      0.46160E-02
VT2222        3543        3544 AC   0.00000E+00
LT2222        1504        3543      0.95753E-09
RT2223        3546        1700      0.46160E-02
VT2223        3545        3546 AC   0.00000E+00
LT2223        1507        3545      0.95753E-09
RT2224        3548        1703      0.46160E-02
VT2224        3547        3548 AC   0.00000E+00
LT2224        1510        3547      0.95753E-09
RT2225        3550        1706      0.46160E-02
VT2225        3549        3550 AC   0.00000E+00
LT2225        1513        3549      0.24269E-09
RT2226        3552        1707      0.46160E-02
VT2226        3551        3552 AC   0.00000E+00
LT2226        1514        3551      0.29070E-09
RT2227        3554        1710      0.46160E-02
VT2227        3553        3554 AC   0.00000E+00
LT2227        1517        3553      0.95753E-09
RT2228        3556        1713      0.46160E-02
VT2228        3555        3556 AC   0.00000E+00
LT2228        1520        3555      0.95753E-09
RT2229        3558        1716      0.46160E-02
VT2229        3557        3558 AC   0.00000E+00
LT2229        1523        3557      0.95753E-09
RT2230        3560        1719      0.46160E-02
VT2230        3559        3560 AC   0.00000E+00
LT2230        1526        3559      0.64812E-09
RT2231        3562        1720      0.46160E-02
VT2231        3561        3562 AC   0.00000E+00
LT2231        1707        3561      0.33871E-09
RT2232        3564        1723      0.46160E-02
VT2232        3563        3564 AC   0.00000E+00
LT2232        1710        3563      0.95753E-09
RT2233        3566        1726      0.46160E-02
VT2233        3565        3566 AC   0.00000E+00
LT2233        1713        3565      0.95753E-09
RT2234        3568        1729      0.46160E-02
VT2234        3567        3568 AC   0.00000E+00
LT2234        1716        3567      0.95753E-09
RT2235        3570        1732      0.46160E-02
VT2235        3569        3570 AC   0.00000E+00
LT2235        1719        3569      0.33871E-09
RT2236        3572        1733      0.46160E-02
VT2236        3571        3572 AC   0.00000E+00
LT2236        1720        3571      0.33871E-09
RT2237        3574        1736      0.46160E-02
VT2237        3573        3574 AC   0.00000E+00
LT2237        1723        3573      0.95753E-09
RT2238        3576        1739      0.46160E-02
VT2238        3575        3576 AC   0.00000E+00
LT2238        1726        3575      0.95753E-09
RT2239        3578        1742      0.46160E-02
VT2239        3577        3578 AC   0.00000E+00
LT2239        1729        3577      0.95753E-09
RT2240        3580        1745      0.46160E-02
VT2240        3579        3580 AC   0.00000E+00
LT2240        1732        3579      0.33871E-09
RT2241        3582        1746      0.46160E-02
VT2241        3581        3582 AC   0.00000E+00
LT2241        1733        3581      0.33871E-09
RT2242        3584        1749      0.46160E-02
VT2242        3583        3584 AC   0.00000E+00
LT2242        1736        3583      0.95753E-09
RT2243        3586        1752      0.46160E-02
VT2243        3585        3586 AC   0.00000E+00
LT2243        1739        3585      0.95753E-09
RT2244        3588        1755      0.46160E-02
VT2244        3587        3588 AC   0.00000E+00
LT2244        1742        3587      0.95753E-09
RT2245        3590        1758      0.46160E-02
VT2245        3589        3590 AC   0.00000E+00
LT2245        1745        3589      0.33871E-09
RT2246        3592        1759      0.46160E-02
VT2246        3591        3592 AC   0.00000E+00
LT2246        1746        3591      0.33871E-09
RT2247        3594        1762      0.46160E-02
VT2247        3593        3594 AC   0.00000E+00
LT2247        1749        3593      0.95753E-09
RT2248        3596        1765      0.46160E-02
VT2248        3595        3596 AC   0.00000E+00
LT2248        1752        3595      0.95753E-09
RT2249        3598        1768      0.46160E-02
VT2249        3597        3598 AC   0.00000E+00
LT2249        1755        3597      0.95753E-09
RT2250        3600        1771      0.46160E-02
VT2250        3599        3600 AC   0.00000E+00
LT2250        1758        3599      0.33871E-09
RT2251        3602        1772      0.46160E-02
VT2251        3601        3602 AC   0.00000E+00
LT2251        1759        3601      0.33871E-09
RT2252        3604        1775      0.46160E-02
VT2252        3603        3604 AC   0.00000E+00
LT2252        1762        3603      0.95753E-09
RT2253        3606        1778      0.46160E-02
VT2253        3605        3606 AC   0.00000E+00
LT2253        1765        3605      0.95753E-09
RT2254        3608        1781      0.46160E-02
VT2254        3607        3608 AC   0.00000E+00
LT2254        1768        3607      0.95753E-09
RT2255        3610        1784      0.46160E-02
VT2255        3609        3610 AC   0.00000E+00
LT2255        1771        3609      0.33871E-09
RT2256        3612        1785      0.46160E-02
VT2256        3611        3612 AC   0.00000E+00
LT2256        1772        3611      0.33871E-09
RT2257        3614        1788      0.46160E-02
VT2257        3613        3614 AC   0.00000E+00
LT2257        1775        3613      0.95753E-09
RT2258        3616        1791      0.46160E-02
VT2258        3615        3616 AC   0.00000E+00
LT2258        1778        3615      0.95753E-09
RT2259        3618        1794      0.46160E-02
VT2259        3617        3618 AC   0.00000E+00
LT2259        1781        3617      0.95753E-09
RT2260        3620        1797      0.46160E-02
VT2260        3619        3620 AC   0.00000E+00
LT2260        1784        3619      0.33871E-09
RT2261        3622        1798      0.46160E-02
VT2261        3621        3622 AC   0.00000E+00
LT2261        1785        3621      0.33871E-09
RT2262        3624        1801      0.46160E-02
VT2262        3623        3624 AC   0.00000E+00
LT2262        1788        3623      0.95753E-09
RT2263        3626        1804      0.46160E-02
VT2263        3625        3626 AC   0.00000E+00
LT2263        1791        3625      0.95753E-09
RT2264        3628        1807      0.46160E-02
VT2264        3627        3628 AC   0.00000E+00
LT2264        1794        3627      0.95753E-09
RT2265        3630        1810      0.46160E-02
VT2265        3629        3630 AC   0.00000E+00
LT2265        1797        3629      0.33871E-09
RT2266        3632        1811      0.46160E-02
VT2266        3631        3632 AC   0.00000E+00
LT2266        1798        3631      0.33871E-09
RT2267        3634        1814      0.46160E-02
VT2267        3633        3634 AC   0.00000E+00
LT2267        1801        3633      0.95753E-09
RT2268        3636        1817      0.46160E-02
VT2268        3635        3636 AC   0.00000E+00
LT2268        1804        3635      0.95753E-09
RT2269        3638        1820      0.46160E-02
VT2269        3637        3638 AC   0.00000E+00
LT2269        1807        3637      0.95753E-09
RT2270        3640        1823      0.46160E-02
VT2270        3639        3640 AC   0.00000E+00
LT2270        1810        3639      0.33871E-09
RT2271        3642        1824      0.46160E-02
VT2271        3641        3642 AC   0.00000E+00
LT2271        1811        3641      0.33871E-09
RT2272        3644        1827      0.46160E-02
VT2272        3643        3644 AC   0.00000E+00
LT2272        1814        3643      0.95753E-09
RT2273        3646        1830      0.46160E-02
VT2273        3645        3646 AC   0.00000E+00
LT2273        1817        3645      0.95753E-09
RT2274        3648        1833      0.46160E-02
VT2274        3647        3648 AC   0.00000E+00
LT2274        1820        3647      0.95753E-09
RT2275        3650        1836      0.46160E-02
VT2275        3649        3650 AC   0.00000E+00
LT2275        1823        3649      0.33871E-09
RT2276        3652        1837      0.46160E-02
VT2276        3651        3652 AC   0.00000E+00
LT2276        1824        3651      0.33871E-09
RT2277        3654        1840      0.46160E-02
VT2277        3653        3654 AC   0.00000E+00
LT2277        1827        3653      0.95753E-09
RT2278        3656        1843      0.46160E-02
VT2278        3655        3656 AC   0.00000E+00
LT2278        1830        3655      0.95753E-09
RT2279        3658        1846      0.46160E-02
VT2279        3657        3658 AC   0.00000E+00
LT2279        1833        3657      0.95753E-09
RT2280        3660        1849      0.46160E-02
VT2280        3659        3660 AC   0.00000E+00
LT2280        1836        3659      0.33871E-09
RT2281        3662        1850      0.46160E-02
VT2281        3661        3662 AC   0.00000E+00
LT2281        1837        3661      0.33871E-09
RT2282        3664        1853      0.46160E-02
VT2282        3663        3664 AC   0.00000E+00
LT2282        1840        3663      0.95753E-09
RT2283        3666        1856      0.46160E-02
VT2283        3665        3666 AC   0.00000E+00
LT2283        1843        3665      0.95753E-09
RT2284        3668        1859      0.46160E-02
VT2284        3667        3668 AC   0.00000E+00
LT2284        1846        3667      0.95753E-09
RT2285        3670        1862      0.46160E-02
VT2285        3669        3670 AC   0.00000E+00
LT2285        1849        3669      0.33871E-09
RT2286        3672        1863      0.46160E-02
VT2286        3671        3672 AC   0.00000E+00
LT2286        1850        3671      0.33871E-09
RT2287        3674        1866      0.46160E-02
VT2287        3673        3674 AC   0.00000E+00
LT2287        1853        3673      0.95753E-09
RT2288        3676        1869      0.46160E-02
VT2288        3675        3676 AC   0.00000E+00
LT2288        1856        3675      0.95753E-09
RT2289        3678        1872      0.46160E-02
VT2289        3677        3678 AC   0.00000E+00
LT2289        1859        3677      0.95753E-09
RT2290        3680        1875      0.46160E-02
VT2290        3679        3680 AC   0.00000E+00
LT2290        1862        3679      0.33871E-09
RT2291        3682        1876      0.46160E-02
VT2291        3681        3682 AC   0.00000E+00
LT2291        1863        3681      0.33871E-09
RT2292        3684        1879      0.46160E-02
VT2292        3683        3684 AC   0.00000E+00
LT2292        1866        3683      0.95753E-09
RT2293        3686        1882      0.46160E-02
VT2293        3685        3686 AC   0.00000E+00
LT2293        1869        3685      0.95753E-09
RT2294        3688        1885      0.46160E-02
VT2294        3687        3688 AC   0.00000E+00
LT2294        1872        3687      0.95753E-09
RT2295        3690        1888      0.46160E-02
VT2295        3689        3690 AC   0.00000E+00
LT2295        1875        3689      0.33871E-09
RT2296        3692        1889      0.46160E-02
VT2296        3691        3692 AC   0.00000E+00
LT2296        1876        3691      0.33871E-09
RT2297        3694        1892      0.46160E-02
VT2297        3693        3694 AC   0.00000E+00
LT2297        1879        3693      0.95753E-09
RT2298        3696        1895      0.46160E-02
VT2298        3695        3696 AC   0.00000E+00
LT2298        1882        3695      0.95753E-09
RT2299        3698        1898      0.46160E-02
VT2299        3697        3698 AC   0.00000E+00
LT2299        1885        3697      0.95753E-09
RT2300        3700        1901      0.46160E-02
VT2300        3699        3700 AC   0.00000E+00
LT2300        1888        3699      0.33871E-09
RT2301        3702        1902      0.46160E-02
VT2301        3701        3702 AC   0.00000E+00
LT2301        1889        3701      0.33871E-09
RT2302        3704        1905      0.46160E-02
VT2302        3703        3704 AC   0.00000E+00
LT2302        1892        3703      0.95753E-09
RT2303        3706        1908      0.46160E-02
VT2303        3705        3706 AC   0.00000E+00
LT2303        1895        3705      0.95753E-09
RT2304        3708        1911      0.46160E-02
VT2304        3707        3708 AC   0.00000E+00
LT2304        1898        3707      0.95753E-09
RT2305        3710        1914      0.46160E-02
VT2305        3709        3710 AC   0.00000E+00
LT2305        1901        3709      0.33871E-09
RT2306        3712        1915      0.46160E-02
VT2306        3711        3712 AC   0.00000E+00
LT2306        1902        3711      0.33871E-09
RT2307        3714        1918      0.46160E-02
VT2307        3713        3714 AC   0.00000E+00
LT2307        1905        3713      0.95753E-09
RT2308        3716        1921      0.46160E-02
VT2308        3715        3716 AC   0.00000E+00
LT2308        1908        3715      0.95753E-09
RT2309        3718        1924      0.46160E-02
VT2309        3717        3718 AC   0.00000E+00
LT2309        1911        3717      0.95753E-09
RT2310        3720        1927      0.46160E-02
VT2310        3719        3720 AC   0.00000E+00
LT2310        1914        3719      0.33871E-09
RT2311        3722        1928      0.46160E-02
VT2311        3721        3722 AC   0.00000E+00
LT2311        1915        3721      0.33871E-09
RT2312        3724        1931      0.46160E-02
VT2312        3723        3724 AC   0.00000E+00
LT2312        1918        3723      0.95753E-09
RT2313        3726        1934      0.46160E-02
VT2313        3725        3726 AC   0.00000E+00
LT2313        1921        3725      0.95753E-09
RT2314        3728        1937      0.46160E-02
VT2314        3727        3728 AC   0.00000E+00
LT2314        1924        3727      0.95753E-09
RT2315        3730        1940      0.46160E-02
VT2315        3729        3730 AC   0.00000E+00
LT2315        1927        3729      0.33871E-09
RT2316        3732        1941      0.46160E-02
VT2316        3731        3732 AC   0.00000E+00
LT2316        1928        3731      0.33871E-09
RT2317        3734        1944      0.46160E-02
VT2317        3733        3734 AC   0.00000E+00
LT2317        1931        3733      0.95753E-09
RT2318        3736        1947      0.46160E-02
VT2318        3735        3736 AC   0.00000E+00
LT2318        1934        3735      0.95753E-09
RT2319        3738        1950      0.46160E-02
VT2319        3737        3738 AC   0.00000E+00
LT2319        1937        3737      0.95753E-09
RT2320        3740        1953      0.46160E-02
VT2320        3739        3740 AC   0.00000E+00
LT2320        1940        3739      0.33871E-09
RT2321        3742        1954      0.46160E-02
VT2321        3741        3742 AC   0.00000E+00
LT2321        1941        3741      0.33871E-09
RT2322        3744        1957      0.46160E-02
VT2322        3743        3744 AC   0.00000E+00
LT2322        1944        3743      0.95753E-09
RT2323        3746        1960      0.46160E-02
VT2323        3745        3746 AC   0.00000E+00
LT2323        1947        3745      0.95753E-09
RT2324        3748        1963      0.46160E-02
VT2324        3747        3748 AC   0.00000E+00
LT2324        1950        3747      0.95753E-09
RT2325        3750        1966      0.46160E-02
VT2325        3749        3750 AC   0.00000E+00
LT2325        1953        3749      0.33871E-09
RT2326        3752        1967      0.46160E-02
VT2326        3751        3752 AC   0.00000E+00
LT2326        1954        3751      0.33871E-09
RT2327        3754        1970      0.46160E-02
VT2327        3753        3754 AC   0.00000E+00
LT2327        1957        3753      0.95753E-09
RT2328        3756        1973      0.46160E-02
VT2328        3755        3756 AC   0.00000E+00
LT2328        1960        3755      0.95753E-09
RT2329        3758        1976      0.46160E-02
VT2329        3757        3758 AC   0.00000E+00
LT2329        1963        3757      0.95753E-09
RT2330        3760        1979      0.46160E-02
VT2330        3759        3760 AC   0.00000E+00
LT2330        1966        3759      0.33871E-09
RT2331        3762        1980      0.46160E-02
VT2331        3761        3762 AC   0.00000E+00
LT2331        1967        3761      0.33871E-09
RT2332        3764        1983      0.46160E-02
VT2332        3763        3764 AC   0.00000E+00
LT2332        1970        3763      0.95753E-09
RT2333        3766        1986      0.46160E-02
VT2333        3765        3766 AC   0.00000E+00
LT2333        1973        3765      0.95753E-09
RT2334        3768        1989      0.46160E-02
VT2334        3767        3768 AC   0.00000E+00
LT2334        1976        3767      0.95753E-09
RT2335        3770        1992      0.46160E-02
VT2335        3769        3770 AC   0.00000E+00
LT2335        1979        3769      0.33871E-09
RT2336        3772        1993      0.46160E-02
VT2336        3771        3772 AC   0.00000E+00
LT2336        1980        3771      0.33871E-09
RT2337        3774        1996      0.46160E-02
VT2337        3773        3774 AC   0.00000E+00
LT2337        1983        3773      0.95753E-09
RT2338        3776        1999      0.46160E-02
VT2338        3775        3776 AC   0.00000E+00
LT2338        1986        3775      0.95753E-09
RT2339        3778        2002      0.46160E-02
VT2339        3777        3778 AC   0.00000E+00
LT2339        1989        3777      0.95753E-09
RT2340        3780        2005      0.46160E-02
VT2340        3779        3780 AC   0.00000E+00
LT2340        1992        3779      0.33871E-09
RT2341        3782        2006      0.46160E-02
VT2341        3781        3782 AC   0.00000E+00
LT2341        1993        3781      0.33871E-09
RT2342        3784        2009      0.46160E-02
VT2342        3783        3784 AC   0.00000E+00
LT2342        1996        3783      0.95753E-09
RT2343        3786        2012      0.46160E-02
VT2343        3785        3786 AC   0.00000E+00
LT2343        1999        3785      0.95753E-09
RT2344        3788        2015      0.46160E-02
VT2344        3787        3788 AC   0.00000E+00
LT2344        2002        3787      0.95753E-09
RT2345        3790        2018      0.46160E-02
VT2345        3789        3790 AC   0.00000E+00
LT2345        2005        3789      0.33871E-09
RT2346        3792        2019      0.46160E-02
VT2346        3791        3792 AC   0.00000E+00
LT2346        2006        3791      0.33871E-09
RT2347        3794        2022      0.46160E-02
VT2347        3793        3794 AC   0.00000E+00
LT2347        2009        3793      0.95753E-09
RT2348        3796        2025      0.46160E-02
VT2348        3795        3796 AC   0.00000E+00
LT2348        2012        3795      0.95753E-09
RT2349        3798        2028      0.46160E-02
VT2349        3797        3798 AC   0.00000E+00
LT2349        2015        3797      0.95753E-09
RT2350        3800        2031      0.46160E-02
VT2350        3799        3800 AC   0.00000E+00
LT2350        2018        3799      0.33871E-09
RT2351        3802        2032      0.46160E-02
VT2351        3801        3802 AC   0.00000E+00
LT2351        2019        3801      0.33871E-09
RT2352        3804        2035      0.46160E-02
VT2352        3803        3804 AC   0.00000E+00
LT2352        2022        3803      0.95753E-09
RT2353        3806        2038      0.46160E-02
VT2353        3805        3806 AC   0.00000E+00
LT2353        2025        3805      0.95753E-09
RT2354        3808        2041      0.46160E-02
VT2354        3807        3808 AC   0.00000E+00
LT2354        2028        3807      0.95753E-09
RT2355        3810        2044      0.46160E-02
VT2355        3809        3810 AC   0.00000E+00
LT2355        2031        3809      0.33871E-09
RT2356        3812        2045      0.46160E-02
VT2356        3811        3812 AC   0.00000E+00
LT2356        2032        3811      0.33871E-09
RT2357        3814        2048      0.46160E-02
VT2357        3813        3814 AC   0.00000E+00
LT2357        2035        3813      0.95753E-09
RT2358        3816        2051      0.46160E-02
VT2358        3815        3816 AC   0.00000E+00
LT2358        2038        3815      0.95753E-09
RT2359        3818        2054      0.46160E-02
VT2359        3817        3818 AC   0.00000E+00
LT2359        2041        3817      0.95753E-09
RT2360        3820        2057      0.46160E-02
VT2360        3819        3820 AC   0.00000E+00
LT2360        2044        3819      0.33871E-09
RT2361        3822        2058      0.46160E-02
VT2361        3821        3822 AC   0.00000E+00
LT2361        2045        3821      0.33871E-09
RT2362        3824        2061      0.46160E-02
VT2362        3823        3824 AC   0.00000E+00
LT2362        2048        3823      0.95753E-09
RT2363        3826        2064      0.46160E-02
VT2363        3825        3826 AC   0.00000E+00
LT2363        2051        3825      0.95753E-09
RT2364        3828        2067      0.46160E-02
VT2364        3827        3828 AC   0.00000E+00
LT2364        2054        3827      0.95753E-09
RT2365        3830        2070      0.46160E-02
VT2365        3829        3830 AC   0.00000E+00
LT2365        2057        3829      0.33871E-09
RT2366        3832        2071      0.46160E-02
VT2366        3831        3832 AC   0.00000E+00
LT2366        2058        3831      0.33871E-09
RT2367        3834        2074      0.46160E-02
VT2367        3833        3834 AC   0.00000E+00
LT2367        2061        3833      0.95753E-09
RT2368        3836        2077      0.46160E-02
VT2368        3835        3836 AC   0.00000E+00
LT2368        2064        3835      0.95753E-09
RT2369        3838        2080      0.46160E-02
VT2369        3837        3838 AC   0.00000E+00
LT2369        2067        3837      0.95753E-09
RT2370        3840        2083      0.46160E-02
VT2370        3839        3840 AC   0.00000E+00
LT2370        2070        3839      0.33871E-09
RT2371        3842        2084      0.46160E-02
VT2371        3841        3842 AC   0.00000E+00
LT2371        2071        3841      0.33871E-09
RT2372        3844        2087      0.46160E-02
VT2372        3843        3844 AC   0.00000E+00
LT2372        2074        3843      0.95753E-09
RT2373        3846        2090      0.46160E-02
VT2373        3845        3846 AC   0.00000E+00
LT2373        2077        3845      0.95753E-09
RT2374        3848        2093      0.46160E-02
VT2374        3847        3848 AC   0.00000E+00
LT2374        2080        3847      0.95753E-09
RT2375        3850        2096      0.46160E-02
VT2375        3849        3850 AC   0.00000E+00
LT2375        2083        3849      0.33871E-09
RT2376        3852        2097      0.46160E-02
VT2376        3851        3852 AC   0.00000E+00
LT2376        2084        3851      0.33871E-09
RT2377        3854        2100      0.46160E-02
VT2377        3853        3854 AC   0.00000E+00
LT2377        2087        3853      0.95753E-09
RT2378        3856        2103      0.46160E-02
VT2378        3855        3856 AC   0.00000E+00
LT2378        2090        3855      0.95753E-09
RT2379        3858        2106      0.46160E-02
VT2379        3857        3858 AC   0.00000E+00
LT2379        2093        3857      0.95753E-09
RT2380        3860        2109      0.46160E-02
VT2380        3859        3860 AC   0.00000E+00
LT2380        2096        3859      0.33871E-09
RT2381        3862        2110      0.46160E-02
VT2381        3861        3862 AC   0.00000E+00
LT2381        2097        3861      0.33871E-09
RT2382        3864        2113      0.46160E-02
VT2382        3863        3864 AC   0.00000E+00
LT2382        2100        3863      0.95753E-09
RT2383        3866        2116      0.46160E-02
VT2383        3865        3866 AC   0.00000E+00
LT2383        2103        3865      0.95753E-09
RT2384        3868        2119      0.46160E-02
VT2384        3867        3868 AC   0.00000E+00
LT2384        2106        3867      0.95753E-09
RT2385        3870        2122      0.46160E-02
VT2385        3869        3870 AC   0.00000E+00
LT2385        2109        3869      0.33871E-09
RT2386        3872        2123      0.46160E-02
VT2386        3871        3872 AC   0.00000E+00
LT2386        2110        3871      0.33871E-09
RT2387        3874        2126      0.46160E-02
VT2387        3873        3874 AC   0.00000E+00
LT2387        2113        3873      0.95753E-09
RT2388        3876        2129      0.46160E-02
VT2388        3875        3876 AC   0.00000E+00
LT2388        2116        3875      0.95753E-09
RT2389        3878        2132      0.46160E-02
VT2389        3877        3878 AC   0.00000E+00
LT2389        2119        3877      0.95753E-09
RT2390        3880        2135      0.46160E-02
VT2390        3879        3880 AC   0.00000E+00
LT2390        2122        3879      0.33871E-09
RT2391        3882        2136      0.46160E-02
VT2391        3881        3882 AC   0.00000E+00
LT2391        2123        3881      0.33871E-09
RT2392        3884        2139      0.46160E-02
VT2392        3883        3884 AC   0.00000E+00
LT2392        2126        3883      0.95753E-09
RT2393        3886        2142      0.46160E-02
VT2393        3885        3886 AC   0.00000E+00
LT2393        2129        3885      0.95753E-09
RT2394        3888        2145      0.46160E-02
VT2394        3887        3888 AC   0.00000E+00
LT2394        2132        3887      0.95753E-09
RT2395        3890        2148      0.46160E-02
VT2395        3889        3890 AC   0.00000E+00
LT2395        2135        3889      0.33871E-09
RT2396        3892        2149      0.46160E-02
VT2396        3891        3892 AC   0.00000E+00
LT2396        2136        3891      0.33871E-09
RT2397        3894        2152      0.46160E-02
VT2397        3893        3894 AC   0.00000E+00
LT2397        2139        3893      0.95753E-09
RT2398        3896        2155      0.46160E-02
VT2398        3895        3896 AC   0.00000E+00
LT2398        2142        3895      0.95753E-09
RT2399        3898        2158      0.46160E-02
VT2399        3897        3898 AC   0.00000E+00
LT2399        2145        3897      0.95753E-09
RT2400        3900        2161      0.46160E-02
VT2400        3899        3900 AC   0.00000E+00
LT2400        2148        3899      0.33871E-09
RT2401        3902        2162      0.46160E-02
VT2401        3901        3902 AC   0.00000E+00
LT2401        2149        3901      0.33871E-09
RT2402        3904        2165      0.46160E-02
VT2402        3903        3904 AC   0.00000E+00
LT2402        2152        3903      0.95753E-09
RT2403        3906        2168      0.46160E-02
VT2403        3905        3906 AC   0.00000E+00
LT2403        2155        3905      0.95753E-09
RT2404        3908        2171      0.46160E-02
VT2404        3907        3908 AC   0.00000E+00
LT2404        2158        3907      0.95753E-09
RT2405        3910        2174      0.46160E-02
VT2405        3909        3910 AC   0.00000E+00
LT2405        2161        3909      0.33871E-09
RT2406        3912        2175      0.46160E-02
VT2406        3911        3912 AC   0.00000E+00
LT2406        2162        3911      0.33871E-09
RT2407        3914        2178      0.46160E-02
VT2407        3913        3914 AC   0.00000E+00
LT2407        2165        3913      0.95753E-09
RT2408        3916        2181      0.46160E-02
VT2408        3915        3916 AC   0.00000E+00
LT2408        2168        3915      0.95753E-09
RT2409        3918        2184      0.46160E-02
VT2409        3917        3918 AC   0.00000E+00
LT2409        2171        3917      0.95753E-09
RT2410        3920        2187      0.46160E-02
VT2410        3919        3920 AC   0.00000E+00
LT2410        2174        3919      0.33871E-09
RT2411        3922        2188      0.46160E-02
VT2411        3921        3922 AC   0.00000E+00
LT2411        2175        3921      0.33871E-09
RT2412        3924        2191      0.46160E-02
VT2412        3923        3924 AC   0.00000E+00
LT2412        2178        3923      0.95753E-09
RT2413        3926        2194      0.46160E-02
VT2413        3925        3926 AC   0.00000E+00
LT2413        2181        3925      0.95753E-09
RT2414        3928        2197      0.46160E-02
VT2414        3927        3928 AC   0.00000E+00
LT2414        2184        3927      0.95753E-09
RT2415        3930        2200      0.46160E-02
VT2415        3929        3930 AC   0.00000E+00
LT2415        2187        3929      0.33871E-09
RT2416        3932        2201      0.46160E-02
VT2416        3931        3932 AC   0.00000E+00
LT2416        2188        3931      0.33871E-09
RT2417        3934        2204      0.46160E-02
VT2417        3933        3934 AC   0.00000E+00
LT2417        2191        3933      0.95753E-09
RT2418        3936        2207      0.46160E-02
VT2418        3935        3936 AC   0.00000E+00
LT2418        2194        3935      0.95753E-09
RT2419        3938        2210      0.46160E-02
VT2419        3937        3938 AC   0.00000E+00
LT2419        2197        3937      0.95753E-09
RT2420        3940        2213      0.46160E-02
VT2420        3939        3940 AC   0.00000E+00
LT2420        2200        3939      0.33871E-09
RT2421        3942        2214      0.46160E-02
VT2421        3941        3942 AC   0.00000E+00
LT2421        2201        3941      0.33871E-09
RT2422        3944        2217      0.46160E-02
VT2422        3943        3944 AC   0.00000E+00
LT2422        2204        3943      0.95753E-09
RT2423        3946        2220      0.46160E-02
VT2423        3945        3946 AC   0.00000E+00
LT2423        2207        3945      0.95753E-09
RT2424        3948        2223      0.46160E-02
VT2424        3947        3948 AC   0.00000E+00
LT2424        2210        3947      0.95753E-09
RT2425        3950        2226      0.46160E-02
VT2425        3949        3950 AC   0.00000E+00
LT2425        2213        3949      0.33871E-09
RT2426        3952        2227      0.46160E-02
VT2426        3951        3952 AC   0.00000E+00
LT2426        2214        3951      0.33871E-09
RT2427        3954        2230      0.46160E-02
VT2427        3953        3954 AC   0.00000E+00
LT2427        2217        3953      0.95753E-09
RT2428        3956        2233      0.46160E-02
VT2428        3955        3956 AC   0.00000E+00
LT2428        2220        3955      0.95753E-09
RT2429        3958        2236      0.46160E-02
VT2429        3957        3958 AC   0.00000E+00
LT2429        2223        3957      0.95753E-09
RT2430        3960        2239      0.46160E-02
VT2430        3959        3960 AC   0.00000E+00
LT2430        2226        3959      0.33871E-09
RT2431        3962        2240      0.46160E-02
VT2431        3961        3962 AC   0.00000E+00
LT2431        2227        3961      0.33871E-09
RT2432        3964        2243      0.46160E-02
VT2432        3963        3964 AC   0.00000E+00
LT2432        2230        3963      0.95753E-09
RT2433        3966        2246      0.46160E-02
VT2433        3965        3966 AC   0.00000E+00
LT2433        2233        3965      0.95753E-09
RT2434        3968        2249      0.46160E-02
VT2434        3967        3968 AC   0.00000E+00
LT2434        2236        3967      0.95753E-09
RT2435        3970        2252      0.46160E-02
VT2435        3969        3970 AC   0.00000E+00
LT2435        2239        3969      0.33871E-09
RT2436        3972        2253      0.46160E-02
VT2436        3971        3972 AC   0.00000E+00
LT2436        2240        3971      0.33871E-09
RT2437        3974        2256      0.46160E-02
VT2437        3973        3974 AC   0.00000E+00
LT2437        2243        3973      0.95753E-09
RT2438        3976        2259      0.46160E-02
VT2438        3975        3976 AC   0.00000E+00
LT2438        2246        3975      0.95753E-09
RT2439        3978        2262      0.46160E-02
VT2439        3977        3978 AC   0.00000E+00
LT2439        2249        3977      0.95753E-09
RT2440        3980        2265      0.46160E-02
VT2440        3979        3980 AC   0.00000E+00
LT2440        2252        3979      0.33871E-09
RT2441        3982        2266      0.46160E-02
VT2441        3981        3982 AC   0.00000E+00
LT2441        2253        3981      0.33871E-09
RT2442        3984        2269      0.46160E-02
VT2442        3983        3984 AC   0.00000E+00
LT2442        2256        3983      0.95753E-09
RT2443        3986        2272      0.46160E-02
VT2443        3985        3986 AC   0.00000E+00
LT2443        2259        3985      0.95753E-09
RT2444        3988        2275      0.46160E-02
VT2444        3987        3988 AC   0.00000E+00
LT2444        2262        3987      0.95753E-09
RT2445        3990        2278      0.46160E-02
VT2445        3989        3990 AC   0.00000E+00
LT2445        2265        3989      0.33871E-09
RT2446        3992        2279      0.46160E-02
VT2446        3991        3992 AC   0.00000E+00
LT2446        2266        3991      0.33871E-09
RT2447        3994        2282      0.46160E-02
VT2447        3993        3994 AC   0.00000E+00
LT2447        2269        3993      0.95753E-09
RT2448        3996        2285      0.46160E-02
VT2448        3995        3996 AC   0.00000E+00
LT2448        2272        3995      0.95753E-09
RT2449        3998        2288      0.46160E-02
VT2449        3997        3998 AC   0.00000E+00
LT2449        2275        3997      0.95753E-09
RT2450        4000        2291      0.46160E-02
VT2450        3999        4000 AC   0.00000E+00
LT2450        2278        3999      0.33871E-09
RT2451        4002        2292      0.46160E-02
VT2451        4001        4002 AC   0.00000E+00
LT2451        2279        4001      0.33871E-09
RT2452        4004        2295      0.46160E-02
VT2452        4003        4004 AC   0.00000E+00
LT2452        2282        4003      0.95753E-09
RT2453        4006        2298      0.46160E-02
VT2453        4005        4006 AC   0.00000E+00
LT2453        2285        4005      0.95753E-09
RT2454        4008        2301      0.46160E-02
VT2454        4007        4008 AC   0.00000E+00
LT2454        2288        4007      0.95753E-09
RT2455        4010        2304      0.46160E-02
VT2455        4009        4010 AC   0.00000E+00
LT2455        2291        4009      0.33871E-09
RT2456        4012        2305      0.46160E-02
VT2456        4011        4012 AC   0.00000E+00
LT2456        2292        4011      0.33871E-09
RT2457        4014        2308      0.46160E-02
VT2457        4013        4014 AC   0.00000E+00
LT2457        2295        4013      0.95753E-09
RT2458        4016        2311      0.46160E-02
VT2458        4015        4016 AC   0.00000E+00
LT2458        2298        4015      0.95753E-09
RT2459        4018        2314      0.46160E-02
VT2459        4017        4018 AC   0.00000E+00
LT2459        2301        4017      0.95753E-09
RT2460        4020        2317      0.46160E-02
VT2460        4019        4020 AC   0.00000E+00
LT2460        2304        4019      0.33871E-09
RT2461        4022        2318      0.46160E-02
VT2461        4021        4022 AC   0.00000E+00
LT2461        2305        4021      0.33871E-09
RT2462        4024        2321      0.46160E-02
VT2462        4023        4024 AC   0.00000E+00
LT2462        2308        4023      0.95753E-09
RT2463        4026        2324      0.46160E-02
VT2463        4025        4026 AC   0.00000E+00
LT2463        2311        4025      0.95753E-09
RT2464        4028        2327      0.46160E-02
VT2464        4027        4028 AC   0.00000E+00
LT2464        2314        4027      0.95753E-09
RT2465        4030        2330      0.46160E-02
VT2465        4029        4030 AC   0.00000E+00
LT2465        2317        4029      0.33871E-09
RT2466        4032        2331      0.46160E-02
VT2466        4031        4032 AC   0.00000E+00
LT2466        2318        4031      0.33871E-09
RT2467        4034        2334      0.46160E-02
VT2467        4033        4034 AC   0.00000E+00
LT2467        2321        4033      0.95753E-09
RT2468        4036        2337      0.46160E-02
VT2468        4035        4036 AC   0.00000E+00
LT2468        2324        4035      0.95753E-09
RT2469        4038        2340      0.46160E-02
VT2469        4037        4038 AC   0.00000E+00
LT2469        2327        4037      0.95753E-09
RT2470        4040        2343      0.46160E-02
VT2470        4039        4040 AC   0.00000E+00
LT2470        2330        4039      0.33871E-09
RT2471        4042        2344      0.46160E-02
VT2471        4041        4042 AC   0.00000E+00
LT2471        2331        4041      0.33871E-09
RT2472        4044        2347      0.46160E-02
VT2472        4043        4044 AC   0.00000E+00
LT2472        2334        4043      0.95753E-09
RT2473        4046        2350      0.46160E-02
VT2473        4045        4046 AC   0.00000E+00
LT2473        2337        4045      0.95753E-09
RT2474        4048        2353      0.46160E-02
VT2474        4047        4048 AC   0.00000E+00
LT2474        2340        4047      0.95753E-09
RT2475        4050        2356      0.46160E-02
VT2475        4049        4050 AC   0.00000E+00
LT2475        2343        4049      0.33871E-09
RT2476        4052        2357      0.46160E-02
VT2476        4051        4052 AC   0.00000E+00
LT2476        2344        4051      0.33871E-09
RT2477        4054        2360      0.46160E-02
VT2477        4053        4054 AC   0.00000E+00
LT2477        2347        4053      0.95753E-09
RT2478        4056        2363      0.46160E-02
VT2478        4055        4056 AC   0.00000E+00
LT2478        2350        4055      0.95753E-09
RT2479        4058        2366      0.46160E-02
VT2479        4057        4058 AC   0.00000E+00
LT2479        2353        4057      0.95753E-09
RT2480        4060        2369      0.46160E-02
VT2480        4059        4060 AC   0.00000E+00
LT2480        2356        4059      0.33871E-09
RT2481        4062        2370      0.46160E-02
VT2481        4061        4062 AC   0.00000E+00
LT2481        2357        4061      0.33871E-09
RT2482        4064        2373      0.46160E-02
VT2482        4063        4064 AC   0.00000E+00
LT2482        2360        4063      0.95753E-09
RT2483        4066        2376      0.46160E-02
VT2483        4065        4066 AC   0.00000E+00
LT2483        2363        4065      0.95753E-09
RT2484        4068        2379      0.46160E-02
VT2484        4067        4068 AC   0.00000E+00
LT2484        2366        4067      0.95753E-09
RT2485        4070        2382      0.46160E-02
VT2485        4069        4070 AC   0.00000E+00
LT2485        2369        4069      0.33871E-09
RT2486        4072        2383      0.46160E-02
VT2486        4071        4072 AC   0.00000E+00
LT2486        2370        4071      0.33871E-09
RT2487        4074        2386      0.46160E-02
VT2487        4073        4074 AC   0.00000E+00
LT2487        2373        4073      0.95753E-09
RT2488        4076        2389      0.46160E-02
VT2488        4075        4076 AC   0.00000E+00
LT2488        2376        4075      0.95753E-09
RT2489        4078        2392      0.46160E-02
VT2489        4077        4078 AC   0.00000E+00
LT2489        2379        4077      0.95753E-09
RT2490        4080        2395      0.46160E-02
VT2490        4079        4080 AC   0.00000E+00
LT2490        2382        4079      0.33871E-09
RT2491        4082        2396      0.46160E-02
VT2491        4081        4082 AC   0.00000E+00
LT2491        2383        4081      0.33871E-09
RT2492        4084        2399      0.46160E-02
VT2492        4083        4084 AC   0.00000E+00
LT2492        2386        4083      0.95753E-09
RT2493        4086        2402      0.46160E-02
VT2493        4085        4086 AC   0.00000E+00
LT2493        2389        4085      0.95753E-09
RT2494        4088        2405      0.46160E-02
VT2494        4087        4088 AC   0.00000E+00
LT2494        2392        4087      0.95753E-09
RT2495        4090        2408      0.46160E-02
VT2495        4089        4090 AC   0.00000E+00
LT2495        2395        4089      0.33871E-09
RT2496        4092        2409      0.46160E-02
VT2496        4091        4092 AC   0.00000E+00
LT2496        2396        4091      0.33871E-09
RT2497        4094        2412      0.46160E-02
VT2497        4093        4094 AC   0.00000E+00
LT2497        2399        4093      0.95753E-09
RT2498        4096        2415      0.46160E-02
VT2498        4095        4096 AC   0.00000E+00
LT2498        2402        4095      0.95753E-09
RT2499        4098        2418      0.46160E-02
VT2499        4097        4098 AC   0.00000E+00
LT2499        2405        4097      0.95753E-09
RT2500        4100        2421      0.46160E-02
VT2500        4099        4100 AC   0.00000E+00
LT2500        2408        4099      0.33871E-09
RT2501        4102        2422      0.46160E-02
VT2501        4101        4102 AC   0.00000E+00
LT2501        2409        4101      0.33871E-09
RT2502        4104        2425      0.46160E-02
VT2502        4103        4104 AC   0.00000E+00
LT2502        2412        4103      0.95753E-09
RT2503        4106        2428      0.46160E-02
VT2503        4105        4106 AC   0.00000E+00
LT2503        2415        4105      0.95753E-09
RT2504        4108        2431      0.46160E-02
VT2504        4107        4108 AC   0.00000E+00
LT2504        2418        4107      0.95753E-09
RT2505        4110        2434      0.46160E-02
VT2505        4109        4110 AC   0.00000E+00
LT2505        2421        4109      0.33871E-09
RT2506        4112        2435      0.46160E-02
VT2506        4111        4112 AC   0.00000E+00
LT2506        2422        4111      0.33871E-09
RT2507        4114        2438      0.46160E-02
VT2507        4113        4114 AC   0.00000E+00
LT2507        2425        4113      0.95753E-09
RT2508        4116        2441      0.46160E-02
VT2508        4115        4116 AC   0.00000E+00
LT2508        2428        4115      0.95753E-09
RT2509        4118        2444      0.46160E-02
VT2509        4117        4118 AC   0.00000E+00
LT2509        2431        4117      0.95753E-09
RT2510        4120        2447      0.46160E-02
VT2510        4119        4120 AC   0.00000E+00
LT2510        2434        4119      0.33871E-09
RT2511        4122        2448      0.46160E-02
VT2511        4121        4122 AC   0.00000E+00
LT2511        2435        4121      0.33871E-09
RT2512        4124        2451      0.46160E-02
VT2512        4123        4124 AC   0.00000E+00
LT2512        2438        4123      0.95753E-09
RT2513        4126        2454      0.46160E-02
VT2513        4125        4126 AC   0.00000E+00
LT2513        2441        4125      0.95753E-09
RT2514        4128        2457      0.46160E-02
VT2514        4127        4128 AC   0.00000E+00
LT2514        2444        4127      0.95753E-09
RT2515        4130        2460      0.46160E-02
VT2515        4129        4130 AC   0.00000E+00
LT2515        2447        4129      0.33871E-09
*
* SHUNT LOAD:
*
RL1         934           0      0.12325E+03
RL2        1127           0      0.12325E+03
RL3        1320           0      0.12325E+03
RL4        1513           0      0.12325E+03
RL5        1706           0      0.12325E+03
*
* SHUNT LOAD:
*
RL6        2448           0      0.12325E+03
RL7        2451           0      0.12325E+03
RL8        2454           0      0.12325E+03
RL9        2457           0      0.12325E+03
RL10        2460           0      0.12325E+03
*
* SHUNT SOURCE:
*
IL11           0           1 AC   0.20000E+00
IL12           0           4 AC   0.20000E+00
IL13           0           7 AC   0.20000E+00
IL14           0          10 AC   0.20000E+00
IL15           0          13 AC   0.20000E+00
*
.AC LIN  11   0.8380E+09   0.1038E+10
*
*
* (NODE) VOLTAGE FOR X-COLUMN #    1,  Y-ROW #    1:
.PRINT AC VM(1) VP(1)
* (NODE) VOLTAGE FOR X-COLUMN #    1,  Y-ROW #    2:
.PRINT AC VM(4) VP(4)
* (NODE) VOLTAGE FOR X-COLUMN #    1,  Y-ROW #    3:
.PRINT AC VM(7) VP(7)
* (NODE) VOLTAGE FOR X-COLUMN #    1,  Y-ROW #    4:
.PRINT AC VM(10) VP(10)
* (NODE) VOLTAGE FOR X-COLUMN #    1,  Y-ROW #    5:
.PRINT AC VM(13) VP(13)
*
* Y-AXIS CURRENT BELOW NODE X-COLUMN #    1,   Y-ROW #    2:
.PRINT AC IM(VT3     )      IP(VT3     )
* Y-AXIS CURRENT BELOW NODE X-COLUMN #    1,   Y-ROW #    3:
.PRINT AC IM(VT5     )      IP(VT5     )
* Y-AXIS CURRENT BELOW NODE X-COLUMN #    1,   Y-ROW #    4:
.PRINT AC IM(VT7     )      IP(VT7     )
* Y-AXIS CURRENT BELOW NODE X-COLUMN #    1,   Y-ROW #    5:
.PRINT AC IM(VT9     )      IP(VT9     )
*
*   Y-AXIS CURRENT ABOVE NODE X-COLUMN #    1,   Y-ROW #    1:
.PRINT AC IM(VT1681  )      IP(VT1681  )
*   Y-AXIS CURRENT ABOVE NODE X-COLUMN #    1,   Y-ROW #    2:
.PRINT AC IM(VT1682  )      IP(VT1682  )
*   Y-AXIS CURRENT ABOVE NODE X-COLUMN #    1,   Y-ROW #    3:
.PRINT AC IM(VT1683  )      IP(VT1683  )
**   Y-AXIS CURRENT ABOVE NODE X-COLUMN #    1,   Y-ROW #    4:
.PRINT AC IM(VT1684  )      IP(VT1684  )
*   Y-AXIS CURRENT ABOVE NODE X-COLUMN #    1,   Y-ROW #    5:
.PRINT AC IM(VT1685  )      IP(VT1685  )
*
.WIDTH IN=72 OUT=80
*
.OPTIONS ACCT
*
.END
