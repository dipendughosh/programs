CS12 PKG WITH EM2 WB  AC @ 1 GHZ  FULL OUTPUT
.WIDTH IN=72 OUT=80
*
RA1001           0       20001      0.26935E-02
VA1001       20001       20002 AC   0.00000E+00
LA1001       20002       20003      0.10357E-09
CA1002       20003           0      0.16718E-14
RA1002       20003           0      0.41938E+09
CA1003       20006           0      0.16718E-14
RA1003       20006           0      0.41938E+09
RA1004       20005       20006      0.53870E-02
VA1004       20004       20005 AC   0.00000E+00
LA1004       20003       20004      0.20715E-09
CA1005       20009           0      0.16718E-14
RA1005       20009           0      0.41938E+09
RA1006       20008       20009      0.53870E-02
VA1006       20007       20008 AC   0.00000E+00
LA1006       20006       20007      0.20715E-09
CA1007       20012           0      0.16718E-14
RA1007       20012           0      0.41938E+09
RA1008       20011       20012      0.53870E-02
VA1008       20010       20011 AC   0.00000E+00
LA1008       20009       20010      0.20715E-09
CA1009       20015           0      0.16718E-14
RA1009       20015           0      0.41938E+09
RA1010       20014       20015      0.53870E-02
VA1010       20013       20014 AC   0.00000E+00
LA1010       20012       20013      0.20715E-09
CA1011       20018           0      0.16718E-14
RA1011       20018           0      0.41938E+09
RA1012       20017       20018      0.53870E-02
VA1012       20016       20017 AC   0.00000E+00
LA1012       20015       20016      0.20715E-09
CA1013       20021           0      0.16718E-14
RA1013       20021           0      0.41938E+09
RA1014       20020       20021      0.53870E-02
VA1014       20019       20020 AC   0.00000E+00
LA1014       20018       20019      0.20715E-09
CA1015       20024           0      0.16718E-14
RA1015       20024           0      0.41938E+09
RA1016       20023       20024      0.53870E-02
VA1016       20022       20023 AC   0.00000E+00
LA1016       20021       20022      0.20715E-09
CA1017       20027           0      0.16718E-14
RA1017       20027           0      0.41938E+09
RA1018       20026       20027      0.53870E-02
VA1018       20025       20026 AC   0.00000E+00
LA1018       20024       20025      0.20715E-09
CA1019       20030           0      0.18886E-14
RA1019       20030           0      0.41938E+09
RA1020       20029       20030      0.53870E-02
VA1020       20028       20029 AC   0.00000E+00
LA1020       20027       20028      0.18601E-09
CA1021       20033           0      0.18886E-14
RA1021       20033           0      0.41938E+09
RA1022       20032       20033      0.53870E-02
VA1022       20031       20032 AC   0.00000E+00
LA1022       20030       20031      0.16488E-09
CA1023       20036           0      0.18886E-14
RA1023       20036           0      0.41938E+09
RA1024       20035       20036      0.53870E-02
VA1024       20034       20035 AC   0.00000E+00
LA1024       20033       20034      0.16488E-09
CA1025       20039           0      0.18886E-14
RA1025       20039           0      0.41938E+09
RA1026       20038       20039      0.53870E-02
VA1026       20037       20038 AC   0.00000E+00
LA1026       20036       20037      0.16488E-09
CA1027       20042           0      0.18886E-14
RA1027       20042           0      0.41938E+09
RA1028       20041       20042      0.53870E-02
VA1028       20040       20041 AC   0.00000E+00
LA1028       20039       20040      0.16488E-09
CA1029       20045           0      0.18886E-14
RA1029       20045           0      0.41938E+09
RA1030       20044       20045      0.53870E-02
VA1030       20043       20044 AC   0.00000E+00
LA1030       20042       20043      0.16488E-09
CA1031       20048           0      0.18886E-14
RA1031       20048           0      0.41938E+09
RA1032       20047       20048      0.53870E-02
VA1032       20046       20047 AC   0.00000E+00
LA1032       20045       20046      0.16488E-09
CA1033       20051           0      0.18886E-14
RA1033       20051           0      0.41938E+09
RA1034       20050       20051      0.53870E-02
VA1034       20049       20050 AC   0.00000E+00
LA1034       20048       20049      0.16488E-09
CA1035       20054           0      0.18886E-14
RA1035       20054           0      0.41938E+09
RA1036       20053       20054      0.53870E-02
VA1036       20052       20053 AC   0.00000E+00
LA1036       20051       20052      0.16488E-09
CA1037       20057           0      0.18886E-14
RA1037       20057           0      0.41938E+09
RA1038       20056       20057      0.53870E-02
VA1038       20055       20056 AC   0.00000E+00
LA1038       20054       20055      0.16488E-09
CA1039       20060           0      0.18886E-14
RA1039       20060           0      0.41938E+09
RA1040       20059       20060      0.53870E-02
VA1040       20058       20059 AC   0.00000E+00
LA1040       20057       20058      0.16488E-09
CA1041       20063           0      0.15706E-14
RA1041       20063           0      0.41938E+09
RA1042       20062       20063      0.53870E-02
VA1042       20061       20062 AC   0.00000E+00
LA1042       20060       20061      0.19988E-09
CA1043       20066           0      0.15706E-14
RA1043       20066           0      0.41938E+09
RA1044       20065       20066      0.53870E-02
VA1044       20064       20065 AC   0.00000E+00
LA1044       20063       20064      0.23489E-09
CA1045       20069           0      0.15706E-14
RA1045       20069           0      0.41938E+09
RA1046       20068       20069      0.53870E-02
VA1046       20067       20068 AC   0.00000E+00
LA1046       20066       20067      0.23489E-09
CA1047       20072           0      0.15706E-14
RA1047       20072           0      0.41938E+09
RA1048       20071       20072      0.53870E-02
VA1048       20070       20071 AC   0.00000E+00
LA1048       20069       20070      0.23489E-09
CA1049       20075           0      0.15706E-14
RA1049       20075           0      0.41938E+09
RA1050       20074       20075      0.53870E-02
VA1050       20073       20074 AC   0.00000E+00
LA1050       20072       20073      0.23489E-09
CA1051       20078           0      0.15706E-14
RA1051       20078           0      0.41938E+09
RA1052       20077       20078      0.53870E-02
VA1052       20076       20077 AC   0.00000E+00
LA1052       20075       20076      0.23489E-09
CA1053       20081           0      0.15706E-14
RA1053       20081           0      0.41938E+09
RA1054       20080       20081      0.53870E-02
VA1054       20079       20080 AC   0.00000E+00
LA1054       20078       20079      0.23489E-09
CA1055       20084           0      0.15706E-14
RA1055       20084           0      0.41938E+09
RA1056       20083       20084      0.53870E-02
VA1056       20082       20083 AC   0.00000E+00
LA1056       20081       20082      0.23489E-09
CA1057       20087           0      0.15706E-14
RA1057       20087           0      0.41938E+09
RA1058       20086       20087      0.53870E-02
VA1058       20085       20086 AC   0.00000E+00
LA1058       20084       20085      0.23489E-09
CA1059       20090           0      0.15706E-14
RA1059       20090           0      0.41938E+09
RA1060       20089       20090      0.53870E-02
VA1060       20088       20089 AC   0.00000E+00
LA1060       20087       20088      0.23489E-09
CA1061       20093           0      0.15706E-14
RA1061       20093           0      0.41938E+09
RA1062       20092       20093      0.53870E-02
VA1062       20091       20092 AC   0.00000E+00
LA1062       20090       20091      0.23489E-09
CA1063       20096           0      0.15706E-14
RA1063       20096           0      0.41938E+09
RA1064       20095       20096      0.53870E-02
VA1064       20094       20095 AC   0.00000E+00
LA1064       20093       20094      0.23489E-09
CA1065       20099           0      0.16556E-14
RA1065       20099           0      0.41938E+09
RA1066       20098       20099      0.53870E-02
VA1066       20097       20098 AC   0.00000E+00
LA1066       20096       20097      0.22302E-09
CA1067       20102           0      0.16556E-14
RA1067       20102           0      0.41938E+09
RA1068       20101       20102      0.53870E-02
VA1068       20100       20101 AC   0.00000E+00
LA1068       20099       20100      0.21116E-09
CA1069       20105           0      0.16556E-14
RA1069       20105           0      0.41938E+09
RA1070       20104       20105      0.53870E-02
VA1070       20103       20104 AC   0.00000E+00
LA1070       20102       20103      0.21116E-09
CA1071       20108           0      0.16556E-14
RA1071       20108           0      0.41938E+09
RA1072       20107       20108      0.53870E-02
VA1072       20106       20107 AC   0.00000E+00
LA1072       20105       20106      0.21116E-09
CA1073       20111           0      0.16556E-14
RA1073       20111           0      0.41938E+09
RA1074       20110       20111      0.53870E-02
VA1074       20109       20110 AC   0.00000E+00
LA1074       20108       20109      0.21116E-09
CA1075       20114           0      0.16556E-14
RA1075       20114           0      0.41938E+09
RA1076       20113       20114      0.53870E-02
VA1076       20112       20113 AC   0.00000E+00
LA1076       20111       20112      0.21116E-09
CA1077       20117           0      0.16556E-14
RA1077       20117           0      0.41938E+09
RA1078       20116       20117      0.53870E-02
VA1078       20115       20116 AC   0.00000E+00
LA1078       20114       20115      0.21116E-09
CA1079       20120           0      0.16556E-14
RA1079       20120           0      0.41938E+09
RA1080       20119       20120      0.53870E-02
VA1080       20118       20119 AC   0.00000E+00
LA1080       20117       20118      0.21116E-09
CA1081       20123           0      0.16556E-14
RA1081       20123           0      0.41938E+09
RA1082       20122       20123      0.53870E-02
VA1082       20121       20122 AC   0.00000E+00
LA1082       20120       20121      0.21116E-09
CA1083       20126           0      0.16556E-14
RA1083       20126           0      0.41938E+09
RA1084       20125       20126      0.53870E-02
VA1084       20124       20125 AC   0.00000E+00
LA1084       20123       20124      0.21116E-09
CA1085       20129           0      0.16556E-14
RA1085       20129           0      0.41938E+09
RA1086       20128       20129      0.53870E-02
VA1086       20127       20128 AC   0.00000E+00
LA1086       20126       20127      0.21116E-09
CA1087       20132           0      0.16556E-14
RA1087       20132           0      0.41938E+09
RA1088       20131       20132      0.53870E-02
VA1088       20130       20131 AC   0.00000E+00
LA1088       20129       20130      0.21116E-09
CA1089       20135           0      0.16556E-14
RA1089       20135           0      0.41938E+09
RA1090       20134       20135      0.53870E-02
VA1090       20133       20134 AC   0.00000E+00
LA1090       20132       20133      0.21116E-09
CA1091       20138           0      0.17352E-14
RA1091       20138           0      0.41938E+09
RA1092       20137       20138      0.53870E-02
VA1092       20136       20137 AC   0.00000E+00
LA1092       20135       20136      0.21116E-09
RA1093           0       20139      0.26935E-02
VA1093       20139       20140 AC   0.00000E+00
LA1093       20140       20141      0.63835E-09
CA1094       20141           0      0.94876E-15
RA1094       20141           0      0.41938E+09
CA1095       20144           0      0.94876E-15
RA1095       20144           0      0.41938E+09
RA1096       20143       20144      0.53870E-02
VA1096       20142       20143 AC   0.00000E+00
LA1096       20141       20142      0.12767E-08
CA1097       20147           0      0.94876E-15
RA1097       20147           0      0.41938E+09
RA1098       20146       20147      0.53870E-02
VA1098       20145       20146 AC   0.00000E+00
LA1098       20144       20145      0.12767E-08
CA1099       20150           0      0.94876E-15
RA1099       20150           0      0.41938E+09
RA1100       20149       20150      0.53870E-02
VA1100       20148       20149 AC   0.00000E+00
LA1100       20147       20148      0.12767E-08
CA1101       20153           0      0.94876E-15
RA1101       20153           0      0.41938E+09
RA1102       20152       20153      0.53870E-02
VA1102       20151       20152 AC   0.00000E+00
LA1102       20150       20151      0.12767E-08
CA1103       20156           0      0.94876E-15
RA1103       20156           0      0.41938E+09
RA1104       20155       20156      0.53870E-02
VA1104       20154       20155 AC   0.00000E+00
LA1104       20153       20154      0.12767E-08
CA1105       20159           0      0.94876E-15
RA1105       20159           0      0.41938E+09
RA1106       20158       20159      0.53870E-02
VA1106       20157       20158 AC   0.00000E+00
LA1106       20156       20157      0.12767E-08
CA1107       20162           0      0.94876E-15
RA1107       20162           0      0.41938E+09
RA1108       20161       20162      0.53870E-02
VA1108       20160       20161 AC   0.00000E+00
LA1108       20159       20160      0.12767E-08
CA1109       20165           0      0.94876E-15
RA1109       20165           0      0.41938E+09
RA1110       20164       20165      0.53870E-02
VA1110       20163       20164 AC   0.00000E+00
LA1110       20162       20163      0.12767E-08
CA1111       20168           0      0.94876E-15
RA1111       20168           0      0.41938E+09
RA1112       20167       20168      0.53870E-02
VA1112       20166       20167 AC   0.00000E+00
LA1112       20165       20166      0.12767E-08
CA1113       20171           0      0.94876E-15
RA1113       20171           0      0.41938E+09
RA1114       20170       20171      0.53870E-02
VA1114       20169       20170 AC   0.00000E+00
LA1114       20168       20169      0.12767E-08
CA1115       20174           0      0.94876E-15
RA1115       20174           0      0.41938E+09
RA1116       20173       20174      0.53870E-02
VA1116       20172       20173 AC   0.00000E+00
LA1116       20171       20172      0.12767E-08
CA1117       20177           0      0.94876E-15
RA1117       20177           0      0.41938E+09
RA1118       20176       20177      0.53870E-02
VA1118       20175       20176 AC   0.00000E+00
LA1118       20174       20175      0.12767E-08
CA1119       20180           0      0.94876E-15
RA1119       20180           0      0.41938E+09
RA1120       20179       20180      0.53870E-02
VA1120       20178       20179 AC   0.00000E+00
LA1120       20177       20178      0.12767E-08
CA1121       20183           0      0.94876E-15
RA1121       20183           0      0.41938E+09
RA1122       20182       20183      0.53870E-02
VA1122       20181       20182 AC   0.00000E+00
LA1122       20180       20181      0.12767E-08
CA1123       20186           0      0.94876E-15
RA1123       20186           0      0.41938E+09
RA1124       20185       20186      0.53870E-02
VA1124       20184       20185 AC   0.00000E+00
LA1124       20183       20184      0.12767E-08
CA1125       20189           0      0.94876E-15
RA1125       20189           0      0.41938E+09
RA1126       20188       20189      0.53870E-02
VA1126       20187       20188 AC   0.00000E+00
LA1126       20186       20187      0.12767E-08
CA1127       20192           0      0.94876E-15
RA1127       20192           0      0.41938E+09
RA1128       20191       20192      0.53870E-02
VA1128       20190       20191 AC   0.00000E+00
LA1128       20189       20190      0.12767E-08
CA1129       20195           0      0.94876E-15
RA1129       20195           0      0.41938E+09
RA1130       20194       20195      0.53870E-02
VA1130       20193       20194 AC   0.00000E+00
LA1130       20192       20193      0.12767E-08
CA1131       20198           0      0.94876E-15
RA1131       20198           0      0.41938E+09
RA1132       20197       20198      0.53870E-02
VA1132       20196       20197 AC   0.00000E+00
LA1132       20195       20196      0.12767E-08
CA1133       20201           0      0.94876E-15
RA1133       20201           0      0.41938E+09
RA1134       20200       20201      0.53870E-02
VA1134       20199       20200 AC   0.00000E+00
LA1134       20198       20199      0.12767E-08
CA1135       20204           0      0.94876E-15
RA1135       20204           0      0.41938E+09
RA1136       20203       20204      0.53870E-02
VA1136       20202       20203 AC   0.00000E+00
LA1136       20201       20202      0.12767E-08
CA1137       20207           0      0.94876E-15
RA1137       20207           0      0.41938E+09
RA1138       20206       20207      0.53870E-02
VA1138       20205       20206 AC   0.00000E+00
LA1138       20204       20205      0.12767E-08
CA1139       20210           0      0.94876E-15
RA1139       20210           0      0.41938E+09
RA1140       20209       20210      0.53870E-02
VA1140       20208       20209 AC   0.00000E+00
LA1140       20207       20208      0.12767E-08
CA1141       20213           0      0.94876E-15
RA1141       20213           0      0.41938E+09
RA1142       20212       20213      0.53870E-02
VA1142       20211       20212 AC   0.00000E+00
LA1142       20210       20211      0.12767E-08
CA1143       20216           0      0.94876E-15
RA1143       20216           0      0.41938E+09
RA1144       20215       20216      0.53870E-02
VA1144       20214       20215 AC   0.00000E+00
LA1144       20213       20214      0.12767E-08
CA1145       20219           0      0.94876E-15
RA1145       20219           0      0.41938E+09
RA1146       20218       20219      0.53870E-02
VA1146       20217       20218 AC   0.00000E+00
LA1146       20216       20217      0.12767E-08
CA1147       20222           0      0.94876E-15
RA1147       20222           0      0.41938E+09
RA1148       20221       20222      0.53870E-02
VA1148       20220       20221 AC   0.00000E+00
LA1148       20219       20220      0.12767E-08
CA1149       20225           0      0.94876E-15
RA1149       20225           0      0.41938E+09
RA1150       20224       20225      0.53870E-02
VA1150       20223       20224 AC   0.00000E+00
LA1150       20222       20223      0.12767E-08
CA1151       20228           0      0.94876E-15
RA1151       20228           0      0.41938E+09
RA1152       20227       20228      0.53870E-02
VA1152       20226       20227 AC   0.00000E+00
LA1152       20225       20226      0.12767E-08
CA1153       20231           0      0.94876E-15
RA1153       20231           0      0.41938E+09
RA1154       20230       20231      0.53870E-02
VA1154       20229       20230 AC   0.00000E+00
LA1154       20228       20229      0.12767E-08
CA1155       20234           0      0.94876E-15
RA1155       20234           0      0.41938E+09
RA1156       20233       20234      0.53870E-02
VA1156       20232       20233 AC   0.00000E+00
LA1156       20231       20232      0.12767E-08
CA1157       20237           0      0.94876E-15
RA1157       20237           0      0.41938E+09
RA1158       20236       20237      0.53870E-02
VA1158       20235       20236 AC   0.00000E+00
LA1158       20234       20235      0.12767E-08
CA1159       20240           0      0.94876E-15
RA1159       20240           0      0.41938E+09
RA1160       20239       20240      0.53870E-02
VA1160       20238       20239 AC   0.00000E+00
LA1160       20237       20238      0.12767E-08
CA1161       20243           0      0.94876E-15
RA1161       20243           0      0.41938E+09
RA1162       20242       20243      0.53870E-02
VA1162       20241       20242 AC   0.00000E+00
LA1162       20240       20241      0.12767E-08
CA1163       20246           0      0.94876E-15
RA1163       20246           0      0.41938E+09
RA1164       20245       20246      0.53870E-02
VA1164       20244       20245 AC   0.00000E+00
LA1164       20243       20244      0.12767E-08
CA1165       20249           0      0.94876E-15
RA1165       20249           0      0.41938E+09
RA1166       20248       20249      0.53870E-02
VA1166       20247       20248 AC   0.00000E+00
LA1166       20246       20247      0.12767E-08
CA1167       20252           0      0.94876E-15
RA1167       20252           0      0.41938E+09
RA1168       20251       20252      0.53870E-02
VA1168       20250       20251 AC   0.00000E+00
LA1168       20249       20250      0.12767E-08
CA1169       20255           0      0.94876E-15
RA1169       20255           0      0.41938E+09
RA1170       20254       20255      0.53870E-02
VA1170       20253       20254 AC   0.00000E+00
LA1170       20252       20253      0.12767E-08
CA1171       20258           0      0.94876E-15
RA1171       20258           0      0.41938E+09
RA1172       20257       20258      0.53870E-02
VA1172       20256       20257 AC   0.00000E+00
LA1172       20255       20256      0.12767E-08
CA1173       20261           0      0.94876E-15
RA1173       20261           0      0.41938E+09
RA1174       20260       20261      0.53870E-02
VA1174       20259       20260 AC   0.00000E+00
LA1174       20258       20259      0.12767E-08
CA1175       20264           0      0.94876E-15
RA1175       20264           0      0.41938E+09
RA1176       20263       20264      0.53870E-02
VA1176       20262       20263 AC   0.00000E+00
LA1176       20261       20262      0.12767E-08
CA1177       20267           0      0.94876E-15
RA1177       20267           0      0.41938E+09
RA1178       20266       20267      0.53870E-02
VA1178       20265       20266 AC   0.00000E+00
LA1178       20264       20265      0.12767E-08
CA1179       20270           0      0.94876E-15
RA1179       20270           0      0.41938E+09
RA1180       20269       20270      0.53870E-02
VA1180       20268       20269 AC   0.00000E+00
LA1180       20267       20268      0.12767E-08
CA1181       20273           0      0.94876E-15
RA1181       20273           0      0.41938E+09
RA1182       20272       20273      0.53870E-02
VA1182       20271       20272 AC   0.00000E+00
LA1182       20270       20271      0.12767E-08
CA1183       20276           0      0.18149E-14
RA1183       20276           0      0.41938E+09
RA1184       20275       20276      0.53870E-02
VA1184       20274       20275 AC   0.00000E+00
LA1184       20273       20274      0.12767E-08
RA1185           0       20277      0.26935E-02
VA1185       20277       20278 AC   0.00000E+00
LA1185       20278       20279      0.63835E-09
CA1186       20279           0      0.94876E-15
RA1186       20279           0      0.41938E+09
CA1187       20282           0      0.94876E-15
RA1187       20282           0      0.41938E+09
RA1188       20281       20282      0.53870E-02
VA1188       20280       20281 AC   0.00000E+00
LA1188       20279       20280      0.12767E-08
CA1189       20285           0      0.94876E-15
RA1189       20285           0      0.41938E+09
RA1190       20284       20285      0.53870E-02
VA1190       20283       20284 AC   0.00000E+00
LA1190       20282       20283      0.12767E-08
CA1191       20288           0      0.94876E-15
RA1191       20288           0      0.41938E+09
RA1192       20287       20288      0.53870E-02
VA1192       20286       20287 AC   0.00000E+00
LA1192       20285       20286      0.12767E-08
CA1193       20291           0      0.94876E-15
RA1193       20291           0      0.41938E+09
RA1194       20290       20291      0.53870E-02
VA1194       20289       20290 AC   0.00000E+00
LA1194       20288       20289      0.12767E-08
CA1195       20294           0      0.94876E-15
RA1195       20294           0      0.41938E+09
RA1196       20293       20294      0.53870E-02
VA1196       20292       20293 AC   0.00000E+00
LA1196       20291       20292      0.12767E-08
CA1197       20297           0      0.94876E-15
RA1197       20297           0      0.41938E+09
RA1198       20296       20297      0.53870E-02
VA1198       20295       20296 AC   0.00000E+00
LA1198       20294       20295      0.12767E-08
CA1199       20300           0      0.94876E-15
RA1199       20300           0      0.41938E+09
RA1200       20299       20300      0.53870E-02
VA1200       20298       20299 AC   0.00000E+00
LA1200       20297       20298      0.12767E-08
CA1201       20303           0      0.94876E-15
RA1201       20303           0      0.41938E+09
RA1202       20302       20303      0.53870E-02
VA1202       20301       20302 AC   0.00000E+00
LA1202       20300       20301      0.12767E-08
CA1203       20306           0      0.94876E-15
RA1203       20306           0      0.41938E+09
RA1204       20305       20306      0.53870E-02
VA1204       20304       20305 AC   0.00000E+00
LA1204       20303       20304      0.12767E-08
CA1205       20309           0      0.94876E-15
RA1205       20309           0      0.41938E+09
RA1206       20308       20309      0.53870E-02
VA1206       20307       20308 AC   0.00000E+00
LA1206       20306       20307      0.12767E-08
CA1207       20312           0      0.94876E-15
RA1207       20312           0      0.41938E+09
RA1208       20311       20312      0.53870E-02
VA1208       20310       20311 AC   0.00000E+00
LA1208       20309       20310      0.12767E-08
CA1209       20315           0      0.94876E-15
RA1209       20315           0      0.41938E+09
RA1210       20314       20315      0.53870E-02
VA1210       20313       20314 AC   0.00000E+00
LA1210       20312       20313      0.12767E-08
CA1211       20318           0      0.94876E-15
RA1211       20318           0      0.41938E+09
RA1212       20317       20318      0.53870E-02
VA1212       20316       20317 AC   0.00000E+00
LA1212       20315       20316      0.12767E-08
CA1213       20321           0      0.94876E-15
RA1213       20321           0      0.41938E+09
RA1214       20320       20321      0.53870E-02
VA1214       20319       20320 AC   0.00000E+00
LA1214       20318       20319      0.12767E-08
CA1215       20324           0      0.94876E-15
RA1215       20324           0      0.41938E+09
RA1216       20323       20324      0.53870E-02
VA1216       20322       20323 AC   0.00000E+00
LA1216       20321       20322      0.12767E-08
CA1217       20327           0      0.94876E-15
RA1217       20327           0      0.41938E+09
RA1218       20326       20327      0.53870E-02
VA1218       20325       20326 AC   0.00000E+00
LA1218       20324       20325      0.12767E-08
CA1219       20330           0      0.94876E-15
RA1219       20330           0      0.41938E+09
RA1220       20329       20330      0.53870E-02
VA1220       20328       20329 AC   0.00000E+00
LA1220       20327       20328      0.12767E-08
CA1221       20333           0      0.94876E-15
RA1221       20333           0      0.41938E+09
RA1222       20332       20333      0.53870E-02
VA1222       20331       20332 AC   0.00000E+00
LA1222       20330       20331      0.12767E-08
CA1223       20336           0      0.94876E-15
RA1223       20336           0      0.41938E+09
RA1224       20335       20336      0.53870E-02
VA1224       20334       20335 AC   0.00000E+00
LA1224       20333       20334      0.12767E-08
CA1225       20339           0      0.94876E-15
RA1225       20339           0      0.41938E+09
RA1226       20338       20339      0.53870E-02
VA1226       20337       20338 AC   0.00000E+00
LA1226       20336       20337      0.12767E-08
CA1227       20342           0      0.94876E-15
RA1227       20342           0      0.41938E+09
RA1228       20341       20342      0.53870E-02
VA1228       20340       20341 AC   0.00000E+00
LA1228       20339       20340      0.12767E-08
CA1229       20345           0      0.94876E-15
RA1229       20345           0      0.41938E+09
RA1230       20344       20345      0.53870E-02
VA1230       20343       20344 AC   0.00000E+00
LA1230       20342       20343      0.12767E-08
CA1231       20348           0      0.94876E-15
RA1231       20348           0      0.41938E+09
RA1232       20347       20348      0.53870E-02
VA1232       20346       20347 AC   0.00000E+00
LA1232       20345       20346      0.12767E-08
CA1233       20351           0      0.94876E-15
RA1233       20351           0      0.41938E+09
RA1234       20350       20351      0.53870E-02
VA1234       20349       20350 AC   0.00000E+00
LA1234       20348       20349      0.12767E-08
CA1235       20354           0      0.94876E-15
RA1235       20354           0      0.41938E+09
RA1236       20353       20354      0.53870E-02
VA1236       20352       20353 AC   0.00000E+00
LA1236       20351       20352      0.12767E-08
CA1237       20357           0      0.94876E-15
RA1237       20357           0      0.41938E+09
RA1238       20356       20357      0.53870E-02
VA1238       20355       20356 AC   0.00000E+00
LA1238       20354       20355      0.12767E-08
CA1239       20360           0      0.94876E-15
RA1239       20360           0      0.41938E+09
RA1240       20359       20360      0.53870E-02
VA1240       20358       20359 AC   0.00000E+00
LA1240       20357       20358      0.12767E-08
CA1241       20363           0      0.94876E-15
RA1241       20363           0      0.41938E+09
RA1242       20362       20363      0.53870E-02
VA1242       20361       20362 AC   0.00000E+00
LA1242       20360       20361      0.12767E-08
CA1243       20366           0      0.94876E-15
RA1243       20366           0      0.41938E+09
RA1244       20365       20366      0.53870E-02
VA1244       20364       20365 AC   0.00000E+00
LA1244       20363       20364      0.12767E-08
CA1245       20369           0      0.94876E-15
RA1245       20369           0      0.41938E+09
RA1246       20368       20369      0.53870E-02
VA1246       20367       20368 AC   0.00000E+00
LA1246       20366       20367      0.12767E-08
CA1247       20372           0      0.94876E-15
RA1247       20372           0      0.41938E+09
RA1248       20371       20372      0.53870E-02
VA1248       20370       20371 AC   0.00000E+00
LA1248       20369       20370      0.12767E-08
CA1249       20375           0      0.94876E-15
RA1249       20375           0      0.41938E+09
RA1250       20374       20375      0.53870E-02
VA1250       20373       20374 AC   0.00000E+00
LA1250       20372       20373      0.12767E-08
CA1251       20378           0      0.94876E-15
RA1251       20378           0      0.41938E+09
RA1252       20377       20378      0.53870E-02
VA1252       20376       20377 AC   0.00000E+00
LA1252       20375       20376      0.12767E-08
CA1253       20381           0      0.94876E-15
RA1253       20381           0      0.41938E+09
RA1254       20380       20381      0.53870E-02
VA1254       20379       20380 AC   0.00000E+00
LA1254       20378       20379      0.12767E-08
CA1255       20384           0      0.94876E-15
RA1255       20384           0      0.41938E+09
RA1256       20383       20384      0.53870E-02
VA1256       20382       20383 AC   0.00000E+00
LA1256       20381       20382      0.12767E-08
CA1257       20387           0      0.94876E-15
RA1257       20387           0      0.41938E+09
RA1258       20386       20387      0.53870E-02
VA1258       20385       20386 AC   0.00000E+00
LA1258       20384       20385      0.12767E-08
CA1259       20390           0      0.94876E-15
RA1259       20390           0      0.41938E+09
RA1260       20389       20390      0.53870E-02
VA1260       20388       20389 AC   0.00000E+00
LA1260       20387       20388      0.12767E-08
CA1261       20393           0      0.94876E-15
RA1261       20393           0      0.41938E+09
RA1262       20392       20393      0.53870E-02
VA1262       20391       20392 AC   0.00000E+00
LA1262       20390       20391      0.12767E-08
CA1263       20396           0      0.94876E-15
RA1263       20396           0      0.41938E+09
RA1264       20395       20396      0.53870E-02
VA1264       20394       20395 AC   0.00000E+00
LA1264       20393       20394      0.12767E-08
CA1265       20399           0      0.94876E-15
RA1265       20399           0      0.41938E+09
RA1266       20398       20399      0.53870E-02
VA1266       20397       20398 AC   0.00000E+00
LA1266       20396       20397      0.12767E-08
CA1267       20402           0      0.94876E-15
RA1267       20402           0      0.41938E+09
RA1268       20401       20402      0.53870E-02
VA1268       20400       20401 AC   0.00000E+00
LA1268       20399       20400      0.12767E-08
CA1269       20405           0      0.94876E-15
RA1269       20405           0      0.41938E+09
RA1270       20404       20405      0.53870E-02
VA1270       20403       20404 AC   0.00000E+00
LA1270       20402       20403      0.12767E-08
CA1271       20408           0      0.94876E-15
RA1271       20408           0      0.41938E+09
RA1272       20407       20408      0.53870E-02
VA1272       20406       20407 AC   0.00000E+00
LA1272       20405       20406      0.12767E-08
CA1273       20411           0      0.94876E-15
RA1273       20411           0      0.41938E+09
RA1274       20410       20411      0.53870E-02
VA1274       20409       20410 AC   0.00000E+00
LA1274       20408       20409      0.12767E-08
CA1275       20414           0      0.18149E-14
RA1275       20414           0      0.41938E+09
RA1276       20413       20414      0.53870E-02
VA1276       20412       20413 AC   0.00000E+00
LA1276       20411       20412      0.12767E-08
RA1277           0       20415      0.26935E-02
VA1277       20415       20416 AC   0.00000E+00
LA1277       20416       20417      0.63835E-09
CA1278       20417           0      0.94876E-15
RA1278       20417           0      0.41938E+09
CA1279       20420           0      0.94876E-15
RA1279       20420           0      0.41938E+09
RA1280       20419       20420      0.53870E-02
VA1280       20418       20419 AC   0.00000E+00
LA1280       20417       20418      0.12767E-08
CA1281       20423           0      0.94876E-15
RA1281       20423           0      0.41938E+09
RA1282       20422       20423      0.53870E-02
VA1282       20421       20422 AC   0.00000E+00
LA1282       20420       20421      0.12767E-08
CA1283       20426           0      0.94876E-15
RA1283       20426           0      0.41938E+09
RA1284       20425       20426      0.53870E-02
VA1284       20424       20425 AC   0.00000E+00
LA1284       20423       20424      0.12767E-08
CA1285       20429           0      0.94876E-15
RA1285       20429           0      0.41938E+09
RA1286       20428       20429      0.53870E-02
VA1286       20427       20428 AC   0.00000E+00
LA1286       20426       20427      0.12767E-08
CA1287       20432           0      0.94876E-15
RA1287       20432           0      0.41938E+09
RA1288       20431       20432      0.53870E-02
VA1288       20430       20431 AC   0.00000E+00
LA1288       20429       20430      0.12767E-08
CA1289       20435           0      0.94876E-15
RA1289       20435           0      0.41938E+09
RA1290       20434       20435      0.53870E-02
VA1290       20433       20434 AC   0.00000E+00
LA1290       20432       20433      0.12767E-08
CA1291       20438           0      0.94876E-15
RA1291       20438           0      0.41938E+09
RA1292       20437       20438      0.53870E-02
VA1292       20436       20437 AC   0.00000E+00
LA1292       20435       20436      0.12767E-08
CA1293       20441           0      0.94876E-15
RA1293       20441           0      0.41938E+09
RA1294       20440       20441      0.53870E-02
VA1294       20439       20440 AC   0.00000E+00
LA1294       20438       20439      0.12767E-08
CA1295       20444           0      0.94876E-15
RA1295       20444           0      0.41938E+09
RA1296       20443       20444      0.53870E-02
VA1296       20442       20443 AC   0.00000E+00
LA1296       20441       20442      0.12767E-08
CA1297       20447           0      0.94876E-15
RA1297       20447           0      0.41938E+09
RA1298       20446       20447      0.53870E-02
VA1298       20445       20446 AC   0.00000E+00
LA1298       20444       20445      0.12767E-08
CA1299       20450           0      0.94876E-15
RA1299       20450           0      0.41938E+09
RA1300       20449       20450      0.53870E-02
VA1300       20448       20449 AC   0.00000E+00
LA1300       20447       20448      0.12767E-08
CA1301       20453           0      0.94876E-15
RA1301       20453           0      0.41938E+09
RA1302       20452       20453      0.53870E-02
VA1302       20451       20452 AC   0.00000E+00
LA1302       20450       20451      0.12767E-08
CA1303       20456           0      0.94876E-15
RA1303       20456           0      0.41938E+09
RA1304       20455       20456      0.53870E-02
VA1304       20454       20455 AC   0.00000E+00
LA1304       20453       20454      0.12767E-08
CA1305       20459           0      0.94876E-15
RA1305       20459           0      0.41938E+09
RA1306       20458       20459      0.53870E-02
VA1306       20457       20458 AC   0.00000E+00
LA1306       20456       20457      0.12767E-08
CA1307       20462           0      0.94876E-15
RA1307       20462           0      0.41938E+09
RA1308       20461       20462      0.53870E-02
VA1308       20460       20461 AC   0.00000E+00
LA1308       20459       20460      0.12767E-08
CA1309       20465           0      0.94876E-15
RA1309       20465           0      0.41938E+09
RA1310       20464       20465      0.53870E-02
VA1310       20463       20464 AC   0.00000E+00
LA1310       20462       20463      0.12767E-08
CA1311       20468           0      0.94876E-15
RA1311       20468           0      0.41938E+09
RA1312       20467       20468      0.53870E-02
VA1312       20466       20467 AC   0.00000E+00
LA1312       20465       20466      0.12767E-08
CA1313       20471           0      0.94876E-15
RA1313       20471           0      0.41938E+09
RA1314       20470       20471      0.53870E-02
VA1314       20469       20470 AC   0.00000E+00
LA1314       20468       20469      0.12767E-08
CA1315       20474           0      0.94876E-15
RA1315       20474           0      0.41938E+09
RA1316       20473       20474      0.53870E-02
VA1316       20472       20473 AC   0.00000E+00
LA1316       20471       20472      0.12767E-08
CA1317       20477           0      0.94876E-15
RA1317       20477           0      0.41938E+09
RA1318       20476       20477      0.53870E-02
VA1318       20475       20476 AC   0.00000E+00
LA1318       20474       20475      0.12767E-08
CA1319       20480           0      0.94876E-15
RA1319       20480           0      0.41938E+09
RA1320       20479       20480      0.53870E-02
VA1320       20478       20479 AC   0.00000E+00
LA1320       20477       20478      0.12767E-08
CA1321       20483           0      0.94876E-15
RA1321       20483           0      0.41938E+09
RA1322       20482       20483      0.53870E-02
VA1322       20481       20482 AC   0.00000E+00
LA1322       20480       20481      0.12767E-08
CA1323       20486           0      0.94876E-15
RA1323       20486           0      0.41938E+09
RA1324       20485       20486      0.53870E-02
VA1324       20484       20485 AC   0.00000E+00
LA1324       20483       20484      0.12767E-08
CA1325       20489           0      0.94876E-15
RA1325       20489           0      0.41938E+09
RA1326       20488       20489      0.53870E-02
VA1326       20487       20488 AC   0.00000E+00
LA1326       20486       20487      0.12767E-08
CA1327       20492           0      0.94876E-15
RA1327       20492           0      0.41938E+09
RA1328       20491       20492      0.53870E-02
VA1328       20490       20491 AC   0.00000E+00
LA1328       20489       20490      0.12767E-08
CA1329       20495           0      0.94876E-15
RA1329       20495           0      0.41938E+09
RA1330       20494       20495      0.53870E-02
VA1330       20493       20494 AC   0.00000E+00
LA1330       20492       20493      0.12767E-08
CA1331       20498           0      0.94876E-15
RA1331       20498           0      0.41938E+09
RA1332       20497       20498      0.53870E-02
VA1332       20496       20497 AC   0.00000E+00
LA1332       20495       20496      0.12767E-08
CA1333       20501           0      0.94876E-15
RA1333       20501           0      0.41938E+09
RA1334       20500       20501      0.53870E-02
VA1334       20499       20500 AC   0.00000E+00
LA1334       20498       20499      0.12767E-08
CA1335       20504           0      0.94876E-15
RA1335       20504           0      0.41938E+09
RA1336       20503       20504      0.53870E-02
VA1336       20502       20503 AC   0.00000E+00
LA1336       20501       20502      0.12767E-08
CA1337       20507           0      0.94876E-15
RA1337       20507           0      0.41938E+09
RA1338       20506       20507      0.53870E-02
VA1338       20505       20506 AC   0.00000E+00
LA1338       20504       20505      0.12767E-08
CA1339       20510           0      0.94876E-15
RA1339       20510           0      0.41938E+09
RA1340       20509       20510      0.53870E-02
VA1340       20508       20509 AC   0.00000E+00
LA1340       20507       20508      0.12767E-08
CA1341       20513           0      0.94876E-15
RA1341       20513           0      0.41938E+09
RA1342       20512       20513      0.53870E-02
VA1342       20511       20512 AC   0.00000E+00
LA1342       20510       20511      0.12767E-08
CA1343       20516           0      0.94876E-15
RA1343       20516           0      0.41938E+09
RA1344       20515       20516      0.53870E-02
VA1344       20514       20515 AC   0.00000E+00
LA1344       20513       20514      0.12767E-08
CA1345       20519           0      0.94876E-15
RA1345       20519           0      0.41938E+09
RA1346       20518       20519      0.53870E-02
VA1346       20517       20518 AC   0.00000E+00
LA1346       20516       20517      0.12767E-08
CA1347       20522           0      0.94876E-15
RA1347       20522           0      0.41938E+09
RA1348       20521       20522      0.53870E-02
VA1348       20520       20521 AC   0.00000E+00
LA1348       20519       20520      0.12767E-08
CA1349       20525           0      0.94876E-15
RA1349       20525           0      0.41938E+09
RA1350       20524       20525      0.53870E-02
VA1350       20523       20524 AC   0.00000E+00
LA1350       20522       20523      0.12767E-08
CA1351       20528           0      0.94876E-15
RA1351       20528           0      0.41938E+09
RA1352       20527       20528      0.53870E-02
VA1352       20526       20527 AC   0.00000E+00
LA1352       20525       20526      0.12767E-08
CA1353       20531           0      0.94876E-15
RA1353       20531           0      0.41938E+09
RA1354       20530       20531      0.53870E-02
VA1354       20529       20530 AC   0.00000E+00
LA1354       20528       20529      0.12767E-08
CA1355       20534           0      0.94876E-15
RA1355       20534           0      0.41938E+09
RA1356       20533       20534      0.53870E-02
VA1356       20532       20533 AC   0.00000E+00
LA1356       20531       20532      0.12767E-08
CA1357       20537           0      0.94876E-15
RA1357       20537           0      0.41938E+09
RA1358       20536       20537      0.53870E-02
VA1358       20535       20536 AC   0.00000E+00
LA1358       20534       20535      0.12767E-08
CA1359       20540           0      0.94876E-15
RA1359       20540           0      0.41938E+09
RA1360       20539       20540      0.53870E-02
VA1360       20538       20539 AC   0.00000E+00
LA1360       20537       20538      0.12767E-08
CA1361       20543           0      0.94876E-15
RA1361       20543           0      0.41938E+09
RA1362       20542       20543      0.53870E-02
VA1362       20541       20542 AC   0.00000E+00
LA1362       20540       20541      0.12767E-08
CA1363       20546           0      0.94876E-15
RA1363       20546           0      0.41938E+09
RA1364       20545       20546      0.53870E-02
VA1364       20544       20545 AC   0.00000E+00
LA1364       20543       20544      0.12767E-08
CA1365       20549           0      0.94876E-15
RA1365       20549           0      0.41938E+09
RA1366       20548       20549      0.53870E-02
VA1366       20547       20548 AC   0.00000E+00
LA1366       20546       20547      0.12767E-08
CA1367       20552           0      0.18149E-14
RA1367       20552           0      0.41938E+09
RA1368       20551       20552      0.53870E-02
VA1368       20550       20551 AC   0.00000E+00
LA1368       20549       20550      0.12767E-08
RA1369           0       20553      0.26935E-02
VA1369       20553       20554 AC   0.00000E+00
LA1369       20554       20555      0.63835E-09
CA1370       20555           0      0.94876E-15
RA1370       20555           0      0.41938E+09
CA1371       20558           0      0.94876E-15
RA1371       20558           0      0.41938E+09
RA1372       20557       20558      0.53870E-02
VA1372       20556       20557 AC   0.00000E+00
LA1372       20555       20556      0.12767E-08
CA1373       20561           0      0.94876E-15
RA1373       20561           0      0.41938E+09
RA1374       20560       20561      0.53870E-02
VA1374       20559       20560 AC   0.00000E+00
LA1374       20558       20559      0.12767E-08
CA1375       20564           0      0.94876E-15
RA1375       20564           0      0.41938E+09
RA1376       20563       20564      0.53870E-02
VA1376       20562       20563 AC   0.00000E+00
LA1376       20561       20562      0.12767E-08
CA1377       20567           0      0.94876E-15
RA1377       20567           0      0.41938E+09
RA1378       20566       20567      0.53870E-02
VA1378       20565       20566 AC   0.00000E+00
LA1378       20564       20565      0.12767E-08
CA1379       20570           0      0.94876E-15
RA1379       20570           0      0.41938E+09
RA1380       20569       20570      0.53870E-02
VA1380       20568       20569 AC   0.00000E+00
LA1380       20567       20568      0.12767E-08
CA1381       20573           0      0.94876E-15
RA1381       20573           0      0.41938E+09
RA1382       20572       20573      0.53870E-02
VA1382       20571       20572 AC   0.00000E+00
LA1382       20570       20571      0.12767E-08
CA1383       20576           0      0.94876E-15
RA1383       20576           0      0.41938E+09
RA1384       20575       20576      0.53870E-02
VA1384       20574       20575 AC   0.00000E+00
LA1384       20573       20574      0.12767E-08
CA1385       20579           0      0.94876E-15
RA1385       20579           0      0.41938E+09
RA1386       20578       20579      0.53870E-02
VA1386       20577       20578 AC   0.00000E+00
LA1386       20576       20577      0.12767E-08
CA1387       20582           0      0.94876E-15
RA1387       20582           0      0.41938E+09
RA1388       20581       20582      0.53870E-02
VA1388       20580       20581 AC   0.00000E+00
LA1388       20579       20580      0.12767E-08
CA1389       20585           0      0.94876E-15
RA1389       20585           0      0.41938E+09
RA1390       20584       20585      0.53870E-02
VA1390       20583       20584 AC   0.00000E+00
LA1390       20582       20583      0.12767E-08
CA1391       20588           0      0.94876E-15
RA1391       20588           0      0.41938E+09
RA1392       20587       20588      0.53870E-02
VA1392       20586       20587 AC   0.00000E+00
LA1392       20585       20586      0.12767E-08
CA1393       20591           0      0.94876E-15
RA1393       20591           0      0.41938E+09
RA1394       20590       20591      0.53870E-02
VA1394       20589       20590 AC   0.00000E+00
LA1394       20588       20589      0.12767E-08
CA1395       20594           0      0.94876E-15
RA1395       20594           0      0.41938E+09
RA1396       20593       20594      0.53870E-02
VA1396       20592       20593 AC   0.00000E+00
LA1396       20591       20592      0.12767E-08
CA1397       20597           0      0.94876E-15
RA1397       20597           0      0.41938E+09
RA1398       20596       20597      0.53870E-02
VA1398       20595       20596 AC   0.00000E+00
LA1398       20594       20595      0.12767E-08
CA1399       20600           0      0.94876E-15
RA1399       20600           0      0.41938E+09
RA1400       20599       20600      0.53870E-02
VA1400       20598       20599 AC   0.00000E+00
LA1400       20597       20598      0.12767E-08
CA1401       20603           0      0.94876E-15
RA1401       20603           0      0.41938E+09
RA1402       20602       20603      0.53870E-02
VA1402       20601       20602 AC   0.00000E+00
LA1402       20600       20601      0.12767E-08
CA1403       20606           0      0.94876E-15
RA1403       20606           0      0.41938E+09
RA1404       20605       20606      0.53870E-02
VA1404       20604       20605 AC   0.00000E+00
LA1404       20603       20604      0.12767E-08
CA1405       20609           0      0.94876E-15
RA1405       20609           0      0.41938E+09
RA1406       20608       20609      0.53870E-02
VA1406       20607       20608 AC   0.00000E+00
LA1406       20606       20607      0.12767E-08
CA1407       20612           0      0.94876E-15
RA1407       20612           0      0.41938E+09
RA1408       20611       20612      0.53870E-02
VA1408       20610       20611 AC   0.00000E+00
LA1408       20609       20610      0.12767E-08
CA1409       20615           0      0.94876E-15
RA1409       20615           0      0.41938E+09
RA1410       20614       20615      0.53870E-02
VA1410       20613       20614 AC   0.00000E+00
LA1410       20612       20613      0.12767E-08
CA1411       20618           0      0.94876E-15
RA1411       20618           0      0.41938E+09
RA1412       20617       20618      0.53870E-02
VA1412       20616       20617 AC   0.00000E+00
LA1412       20615       20616      0.12767E-08
CA1413       20621           0      0.94876E-15
RA1413       20621           0      0.41938E+09
RA1414       20620       20621      0.53870E-02
VA1414       20619       20620 AC   0.00000E+00
LA1414       20618       20619      0.12767E-08
CA1415       20624           0      0.94876E-15
RA1415       20624           0      0.41938E+09
RA1416       20623       20624      0.53870E-02
VA1416       20622       20623 AC   0.00000E+00
LA1416       20621       20622      0.12767E-08
CA1417       20627           0      0.94876E-15
RA1417       20627           0      0.41938E+09
RA1418       20626       20627      0.53870E-02
VA1418       20625       20626 AC   0.00000E+00
LA1418       20624       20625      0.12767E-08
CA1419       20630           0      0.94876E-15
RA1419       20630           0      0.41938E+09
RA1420       20629       20630      0.53870E-02
VA1420       20628       20629 AC   0.00000E+00
LA1420       20627       20628      0.12767E-08
CA1421       20633           0      0.94876E-15
RA1421       20633           0      0.41938E+09
RA1422       20632       20633      0.53870E-02
VA1422       20631       20632 AC   0.00000E+00
LA1422       20630       20631      0.12767E-08
CA1423       20636           0      0.94876E-15
RA1423       20636           0      0.41938E+09
RA1424       20635       20636      0.53870E-02
VA1424       20634       20635 AC   0.00000E+00
LA1424       20633       20634      0.12767E-08
CA1425       20639           0      0.94876E-15
RA1425       20639           0      0.41938E+09
RA1426       20638       20639      0.53870E-02
VA1426       20637       20638 AC   0.00000E+00
LA1426       20636       20637      0.12767E-08
CA1427       20642           0      0.94876E-15
RA1427       20642           0      0.41938E+09
RA1428       20641       20642      0.53870E-02
VA1428       20640       20641 AC   0.00000E+00
LA1428       20639       20640      0.12767E-08
CA1429       20645           0      0.94876E-15
RA1429       20645           0      0.41938E+09
RA1430       20644       20645      0.53870E-02
VA1430       20643       20644 AC   0.00000E+00
LA1430       20642       20643      0.12767E-08
CA1431       20648           0      0.94876E-15
RA1431       20648           0      0.41938E+09
RA1432       20647       20648      0.53870E-02
VA1432       20646       20647 AC   0.00000E+00
LA1432       20645       20646      0.12767E-08
CA1433       20651           0      0.94876E-15
RA1433       20651           0      0.41938E+09
RA1434       20650       20651      0.53870E-02
VA1434       20649       20650 AC   0.00000E+00
LA1434       20648       20649      0.12767E-08
CA1435       20654           0      0.94876E-15
RA1435       20654           0      0.41938E+09
RA1436       20653       20654      0.53870E-02
VA1436       20652       20653 AC   0.00000E+00
LA1436       20651       20652      0.12767E-08
CA1437       20657           0      0.94876E-15
RA1437       20657           0      0.41938E+09
RA1438       20656       20657      0.53870E-02
VA1438       20655       20656 AC   0.00000E+00
LA1438       20654       20655      0.12767E-08
CA1439       20660           0      0.94876E-15
RA1439       20660           0      0.41938E+09
RA1440       20659       20660      0.53870E-02
VA1440       20658       20659 AC   0.00000E+00
LA1440       20657       20658      0.12767E-08
CA1441       20663           0      0.94876E-15
RA1441       20663           0      0.41938E+09
RA1442       20662       20663      0.53870E-02
VA1442       20661       20662 AC   0.00000E+00
LA1442       20660       20661      0.12767E-08
CA1443       20666           0      0.94876E-15
RA1443       20666           0      0.41938E+09
RA1444       20665       20666      0.53870E-02
VA1444       20664       20665 AC   0.00000E+00
LA1444       20663       20664      0.12767E-08
CA1445       20669           0      0.94876E-15
RA1445       20669           0      0.41938E+09
RA1446       20668       20669      0.53870E-02
VA1446       20667       20668 AC   0.00000E+00
LA1446       20666       20667      0.12767E-08
CA1447       20672           0      0.94876E-15
RA1447       20672           0      0.41938E+09
RA1448       20671       20672      0.53870E-02
VA1448       20670       20671 AC   0.00000E+00
LA1448       20669       20670      0.12767E-08
CA1449       20675           0      0.94876E-15
RA1449       20675           0      0.41938E+09
RA1450       20674       20675      0.53870E-02
VA1450       20673       20674 AC   0.00000E+00
LA1450       20672       20673      0.12767E-08
CA1451       20678           0      0.94876E-15
RA1451       20678           0      0.41938E+09
RA1452       20677       20678      0.53870E-02
VA1452       20676       20677 AC   0.00000E+00
LA1452       20675       20676      0.12767E-08
CA1453       20681           0      0.94876E-15
RA1453       20681           0      0.41938E+09
RA1454       20680       20681      0.53870E-02
VA1454       20679       20680 AC   0.00000E+00
LA1454       20678       20679      0.12767E-08
CA1455       20684           0      0.94876E-15
RA1455       20684           0      0.41938E+09
RA1456       20683       20684      0.53870E-02
VA1456       20682       20683 AC   0.00000E+00
LA1456       20681       20682      0.12767E-08
CA1457       20687           0      0.94876E-15
RA1457       20687           0      0.41938E+09
RA1458       20686       20687      0.53870E-02
VA1458       20685       20686 AC   0.00000E+00
LA1458       20684       20685      0.12767E-08
CA1459       20690           0      0.18149E-14
RA1459       20690           0      0.41938E+09
RA1460       20689       20690      0.53870E-02
VA1460       20688       20689 AC   0.00000E+00
LA1460       20687       20688      0.12767E-08
RA1461           0       20691      0.26935E-02
VA1461       20691       20692 AC   0.00000E+00
LA1461       20692       20693      0.63835E-09
CA1462       20693           0      0.94876E-15
RA1462       20693           0      0.41938E+09
CA1463       20696           0      0.94876E-15
RA1463       20696           0      0.41938E+09
RA1464       20695       20696      0.53870E-02
VA1464       20694       20695 AC   0.00000E+00
LA1464       20693       20694      0.12767E-08
CA1465       20699           0      0.94876E-15
RA1465       20699           0      0.41938E+09
RA1466       20698       20699      0.53870E-02
VA1466       20697       20698 AC   0.00000E+00
LA1466       20696       20697      0.12767E-08
CA1467       20702           0      0.94876E-15
RA1467       20702           0      0.41938E+09
RA1468       20701       20702      0.53870E-02
VA1468       20700       20701 AC   0.00000E+00
LA1468       20699       20700      0.12767E-08
CA1469       20705           0      0.94876E-15
RA1469       20705           0      0.41938E+09
RA1470       20704       20705      0.53870E-02
VA1470       20703       20704 AC   0.00000E+00
LA1470       20702       20703      0.12767E-08
CA1471       20708           0      0.94876E-15
RA1471       20708           0      0.41938E+09
RA1472       20707       20708      0.53870E-02
VA1472       20706       20707 AC   0.00000E+00
LA1472       20705       20706      0.12767E-08
CA1473       20711           0      0.94876E-15
RA1473       20711           0      0.41938E+09
RA1474       20710       20711      0.53870E-02
VA1474       20709       20710 AC   0.00000E+00
LA1474       20708       20709      0.12767E-08
CA1475       20714           0      0.94876E-15
RA1475       20714           0      0.41938E+09
RA1476       20713       20714      0.53870E-02
VA1476       20712       20713 AC   0.00000E+00
LA1476       20711       20712      0.12767E-08
CA1477       20717           0      0.94876E-15
RA1477       20717           0      0.41938E+09
RA1478       20716       20717      0.53870E-02
VA1478       20715       20716 AC   0.00000E+00
LA1478       20714       20715      0.12767E-08
CA1479       20720           0      0.94876E-15
RA1479       20720           0      0.41938E+09
RA1480       20719       20720      0.53870E-02
VA1480       20718       20719 AC   0.00000E+00
LA1480       20717       20718      0.12767E-08
CA1481       20723           0      0.94876E-15
RA1481       20723           0      0.41938E+09
RA1482       20722       20723      0.53870E-02
VA1482       20721       20722 AC   0.00000E+00
LA1482       20720       20721      0.12767E-08
CA1483       20726           0      0.94876E-15
RA1483       20726           0      0.41938E+09
RA1484       20725       20726      0.53870E-02
VA1484       20724       20725 AC   0.00000E+00
LA1484       20723       20724      0.12767E-08
CA1485       20729           0      0.94876E-15
RA1485       20729           0      0.41938E+09
RA1486       20728       20729      0.53870E-02
VA1486       20727       20728 AC   0.00000E+00
LA1486       20726       20727      0.12767E-08
CA1487       20732           0      0.94876E-15
RA1487       20732           0      0.41938E+09
RA1488       20731       20732      0.53870E-02
VA1488       20730       20731 AC   0.00000E+00
LA1488       20729       20730      0.12767E-08
CA1489       20735           0      0.94876E-15
RA1489       20735           0      0.41938E+09
RA1490       20734       20735      0.53870E-02
VA1490       20733       20734 AC   0.00000E+00
LA1490       20732       20733      0.12767E-08
CA1491       20738           0      0.94876E-15
RA1491       20738           0      0.41938E+09
RA1492       20737       20738      0.53870E-02
VA1492       20736       20737 AC   0.00000E+00
LA1492       20735       20736      0.12767E-08
CA1493       20741           0      0.94876E-15
RA1493       20741           0      0.41938E+09
RA1494       20740       20741      0.53870E-02
VA1494       20739       20740 AC   0.00000E+00
LA1494       20738       20739      0.12767E-08
CA1495       20744           0      0.94876E-15
RA1495       20744           0      0.41938E+09
RA1496       20743       20744      0.53870E-02
VA1496       20742       20743 AC   0.00000E+00
LA1496       20741       20742      0.12767E-08
CA1497       20747           0      0.94876E-15
RA1497       20747           0      0.41938E+09
RA1498       20746       20747      0.53870E-02
VA1498       20745       20746 AC   0.00000E+00
LA1498       20744       20745      0.12767E-08
CA1499       20750           0      0.94876E-15
RA1499       20750           0      0.41938E+09
RA1500       20749       20750      0.53870E-02
VA1500       20748       20749 AC   0.00000E+00
LA1500       20747       20748      0.12767E-08
CA1501       20753           0      0.94876E-15
RA1501       20753           0      0.41938E+09
RA1502       20752       20753      0.53870E-02
VA1502       20751       20752 AC   0.00000E+00
LA1502       20750       20751      0.12767E-08
CA1503       20756           0      0.94876E-15
RA1503       20756           0      0.41938E+09
RA1504       20755       20756      0.53870E-02
VA1504       20754       20755 AC   0.00000E+00
LA1504       20753       20754      0.12767E-08
CA1505       20759           0      0.94876E-15
RA1505       20759           0      0.41938E+09
RA1506       20758       20759      0.53870E-02
VA1506       20757       20758 AC   0.00000E+00
LA1506       20756       20757      0.12767E-08
CA1507       20762           0      0.94876E-15
RA1507       20762           0      0.41938E+09
RA1508       20761       20762      0.53870E-02
VA1508       20760       20761 AC   0.00000E+00
LA1508       20759       20760      0.12767E-08
CA1509       20765           0      0.94876E-15
RA1509       20765           0      0.41938E+09
RA1510       20764       20765      0.53870E-02
VA1510       20763       20764 AC   0.00000E+00
LA1510       20762       20763      0.12767E-08
CA1511       20768           0      0.94876E-15
RA1511       20768           0      0.41938E+09
RA1512       20767       20768      0.53870E-02
VA1512       20766       20767 AC   0.00000E+00
LA1512       20765       20766      0.12767E-08
CA1513       20771           0      0.94876E-15
RA1513       20771           0      0.41938E+09
RA1514       20770       20771      0.53870E-02
VA1514       20769       20770 AC   0.00000E+00
LA1514       20768       20769      0.12767E-08
CA1515       20774           0      0.94876E-15
RA1515       20774           0      0.41938E+09
RA1516       20773       20774      0.53870E-02
VA1516       20772       20773 AC   0.00000E+00
LA1516       20771       20772      0.12767E-08
CA1517       20777           0      0.94876E-15
RA1517       20777           0      0.41938E+09
RA1518       20776       20777      0.53870E-02
VA1518       20775       20776 AC   0.00000E+00
LA1518       20774       20775      0.12767E-08
CA1519       20780           0      0.94876E-15
RA1519       20780           0      0.41938E+09
RA1520       20779       20780      0.53870E-02
VA1520       20778       20779 AC   0.00000E+00
LA1520       20777       20778      0.12767E-08
CA1521       20783           0      0.94876E-15
RA1521       20783           0      0.41938E+09
RA1522       20782       20783      0.53870E-02
VA1522       20781       20782 AC   0.00000E+00
LA1522       20780       20781      0.12767E-08
CA1523       20786           0      0.94876E-15
RA1523       20786           0      0.41938E+09
RA1524       20785       20786      0.53870E-02
VA1524       20784       20785 AC   0.00000E+00
LA1524       20783       20784      0.12767E-08
CA1525       20789           0      0.94876E-15
RA1525       20789           0      0.41938E+09
RA1526       20788       20789      0.53870E-02
VA1526       20787       20788 AC   0.00000E+00
LA1526       20786       20787      0.12767E-08
CA1527       20792           0      0.94876E-15
RA1527       20792           0      0.41938E+09
RA1528       20791       20792      0.53870E-02
VA1528       20790       20791 AC   0.00000E+00
LA1528       20789       20790      0.12767E-08
CA1529       20795           0      0.94876E-15
RA1529       20795           0      0.41938E+09
RA1530       20794       20795      0.53870E-02
VA1530       20793       20794 AC   0.00000E+00
LA1530       20792       20793      0.12767E-08
CA1531       20798           0      0.94876E-15
RA1531       20798           0      0.41938E+09
RA1532       20797       20798      0.53870E-02
VA1532       20796       20797 AC   0.00000E+00
LA1532       20795       20796      0.12767E-08
CA1533       20801           0      0.94876E-15
RA1533       20801           0      0.41938E+09
RA1534       20800       20801      0.53870E-02
VA1534       20799       20800 AC   0.00000E+00
LA1534       20798       20799      0.12767E-08
CA1535       20804           0      0.94876E-15
RA1535       20804           0      0.41938E+09
RA1536       20803       20804      0.53870E-02
VA1536       20802       20803 AC   0.00000E+00
LA1536       20801       20802      0.12767E-08
CA1537       20807           0      0.94876E-15
RA1537       20807           0      0.41938E+09
RA1538       20806       20807      0.53870E-02
VA1538       20805       20806 AC   0.00000E+00
LA1538       20804       20805      0.12767E-08
CA1539       20810           0      0.94876E-15
RA1539       20810           0      0.41938E+09
RA1540       20809       20810      0.53870E-02
VA1540       20808       20809 AC   0.00000E+00
LA1540       20807       20808      0.12767E-08
CA1541       20813           0      0.94876E-15
RA1541       20813           0      0.41938E+09
RA1542       20812       20813      0.53870E-02
VA1542       20811       20812 AC   0.00000E+00
LA1542       20810       20811      0.12767E-08
CA1543       20816           0      0.94876E-15
RA1543       20816           0      0.41938E+09
RA1544       20815       20816      0.53870E-02
VA1544       20814       20815 AC   0.00000E+00
LA1544       20813       20814      0.12767E-08
CA1545       20819           0      0.94876E-15
RA1545       20819           0      0.41938E+09
RA1546       20818       20819      0.53870E-02
VA1546       20817       20818 AC   0.00000E+00
LA1546       20816       20817      0.12767E-08
CA1547       20822           0      0.94876E-15
RA1547       20822           0      0.41938E+09
RA1548       20821       20822      0.53870E-02
VA1548       20820       20821 AC   0.00000E+00
LA1548       20819       20820      0.12767E-08
CA1549       20825           0      0.94876E-15
RA1549       20825           0      0.41938E+09
RA1550       20824       20825      0.53870E-02
VA1550       20823       20824 AC   0.00000E+00
LA1550       20822       20823      0.12767E-08
CA1551       20828           0      0.18149E-14
RA1551       20828           0      0.41938E+09
RA1552       20827       20828      0.53870E-02
VA1552       20826       20827 AC   0.00000E+00
LA1552       20825       20826      0.12767E-08
RA1553           0       20829      0.26935E-02
VA1553       20829       20830 AC   0.00000E+00
LA1553       20830       20831      0.63835E-09
CA1554       20831           0      0.94876E-15
RA1554       20831           0      0.41938E+09
CA1555       20834           0      0.94876E-15
RA1555       20834           0      0.41938E+09
RA1556       20833       20834      0.53870E-02
VA1556       20832       20833 AC   0.00000E+00
LA1556       20831       20832      0.12767E-08
CA1557       20837           0      0.94876E-15
RA1557       20837           0      0.41938E+09
RA1558       20836       20837      0.53870E-02
VA1558       20835       20836 AC   0.00000E+00
LA1558       20834       20835      0.12767E-08
CA1559       20840           0      0.94876E-15
RA1559       20840           0      0.41938E+09
RA1560       20839       20840      0.53870E-02
VA1560       20838       20839 AC   0.00000E+00
LA1560       20837       20838      0.12767E-08
CA1561       20843           0      0.94876E-15
RA1561       20843           0      0.41938E+09
RA1562       20842       20843      0.53870E-02
VA1562       20841       20842 AC   0.00000E+00
LA1562       20840       20841      0.12767E-08
CA1563       20846           0      0.94876E-15
RA1563       20846           0      0.41938E+09
RA1564       20845       20846      0.53870E-02
VA1564       20844       20845 AC   0.00000E+00
LA1564       20843       20844      0.12767E-08
CA1565       20849           0      0.94876E-15
RA1565       20849           0      0.41938E+09
RA1566       20848       20849      0.53870E-02
VA1566       20847       20848 AC   0.00000E+00
LA1566       20846       20847      0.12767E-08
CA1567       20852           0      0.94876E-15
RA1567       20852           0      0.41938E+09
RA1568       20851       20852      0.53870E-02
VA1568       20850       20851 AC   0.00000E+00
LA1568       20849       20850      0.12767E-08
CA1569       20855           0      0.94876E-15
RA1569       20855           0      0.41938E+09
RA1570       20854       20855      0.53870E-02
VA1570       20853       20854 AC   0.00000E+00
LA1570       20852       20853      0.12767E-08
CA1571       20858           0      0.94876E-15
RA1571       20858           0      0.41938E+09
RA1572       20857       20858      0.53870E-02
VA1572       20856       20857 AC   0.00000E+00
LA1572       20855       20856      0.12767E-08
CA1573       20861           0      0.94876E-15
RA1573       20861           0      0.41938E+09
RA1574       20860       20861      0.53870E-02
VA1574       20859       20860 AC   0.00000E+00
LA1574       20858       20859      0.12767E-08
CA1575       20864           0      0.94876E-15
RA1575       20864           0      0.41938E+09
RA1576       20863       20864      0.53870E-02
VA1576       20862       20863 AC   0.00000E+00
LA1576       20861       20862      0.12767E-08
CA1577       20867           0      0.94876E-15
RA1577       20867           0      0.41938E+09
RA1578       20866       20867      0.53870E-02
VA1578       20865       20866 AC   0.00000E+00
LA1578       20864       20865      0.12767E-08
CA1579       20870           0      0.94876E-15
RA1579       20870           0      0.41938E+09
RA1580       20869       20870      0.53870E-02
VA1580       20868       20869 AC   0.00000E+00
LA1580       20867       20868      0.12767E-08
CA1581       20873           0      0.94876E-15
RA1581       20873           0      0.41938E+09
RA1582       20872       20873      0.53870E-02
VA1582       20871       20872 AC   0.00000E+00
LA1582       20870       20871      0.12767E-08
CA1583       20876           0      0.94876E-15
RA1583       20876           0      0.41938E+09
RA1584       20875       20876      0.53870E-02
VA1584       20874       20875 AC   0.00000E+00
LA1584       20873       20874      0.12767E-08
CA1585       20879           0      0.94876E-15
RA1585       20879           0      0.41938E+09
RA1586       20878       20879      0.53870E-02
VA1586       20877       20878 AC   0.00000E+00
LA1586       20876       20877      0.12767E-08
CA1587       20882           0      0.94876E-15
RA1587       20882           0      0.41938E+09
RA1588       20881       20882      0.53870E-02
VA1588       20880       20881 AC   0.00000E+00
LA1588       20879       20880      0.12767E-08
CA1589       20885           0      0.94876E-15
RA1589       20885           0      0.41938E+09
RA1590       20884       20885      0.53870E-02
VA1590       20883       20884 AC   0.00000E+00
LA1590       20882       20883      0.12767E-08
CA1591       20888           0      0.94876E-15
RA1591       20888           0      0.41938E+09
RA1592       20887       20888      0.53870E-02
VA1592       20886       20887 AC   0.00000E+00
LA1592       20885       20886      0.12767E-08
CA1593       20891           0      0.94876E-15
RA1593       20891           0      0.41938E+09
RA1594       20890       20891      0.53870E-02
VA1594       20889       20890 AC   0.00000E+00
LA1594       20888       20889      0.12767E-08
CA1595       20894           0      0.94876E-15
RA1595       20894           0      0.41938E+09
RA1596       20893       20894      0.53870E-02
VA1596       20892       20893 AC   0.00000E+00
LA1596       20891       20892      0.12767E-08
CA1597       20897           0      0.94876E-15
RA1597       20897           0      0.41938E+09
RA1598       20896       20897      0.53870E-02
VA1598       20895       20896 AC   0.00000E+00
LA1598       20894       20895      0.12767E-08
CA1599       20900           0      0.94876E-15
RA1599       20900           0      0.41938E+09
RA1600       20899       20900      0.53870E-02
VA1600       20898       20899 AC   0.00000E+00
LA1600       20897       20898      0.12767E-08
CA1601       20903           0      0.94876E-15
RA1601       20903           0      0.41938E+09
RA1602       20902       20903      0.53870E-02
VA1602       20901       20902 AC   0.00000E+00
LA1602       20900       20901      0.12767E-08
CA1603       20906           0      0.94876E-15
RA1603       20906           0      0.41938E+09
RA1604       20905       20906      0.53870E-02
VA1604       20904       20905 AC   0.00000E+00
LA1604       20903       20904      0.12767E-08
CA1605       20909           0      0.94876E-15
RA1605       20909           0      0.41938E+09
RA1606       20908       20909      0.53870E-02
VA1606       20907       20908 AC   0.00000E+00
LA1606       20906       20907      0.12767E-08
CA1607       20912           0      0.94876E-15
RA1607       20912           0      0.41938E+09
RA1608       20911       20912      0.53870E-02
VA1608       20910       20911 AC   0.00000E+00
LA1608       20909       20910      0.12767E-08
CA1609       20915           0      0.94876E-15
RA1609       20915           0      0.41938E+09
RA1610       20914       20915      0.53870E-02
VA1610       20913       20914 AC   0.00000E+00
LA1610       20912       20913      0.12767E-08
CA1611       20918           0      0.94876E-15
RA1611       20918           0      0.41938E+09
RA1612       20917       20918      0.53870E-02
VA1612       20916       20917 AC   0.00000E+00
LA1612       20915       20916      0.12767E-08
CA1613       20921           0      0.94876E-15
RA1613       20921           0      0.41938E+09
RA1614       20920       20921      0.53870E-02
VA1614       20919       20920 AC   0.00000E+00
LA1614       20918       20919      0.12767E-08
CA1615       20924           0      0.94876E-15
RA1615       20924           0      0.41938E+09
RA1616       20923       20924      0.53870E-02
VA1616       20922       20923 AC   0.00000E+00
LA1616       20921       20922      0.12767E-08
CA1617       20927           0      0.94876E-15
RA1617       20927           0      0.41938E+09
RA1618       20926       20927      0.53870E-02
VA1618       20925       20926 AC   0.00000E+00
LA1618       20924       20925      0.12767E-08
CA1619       20930           0      0.94876E-15
RA1619       20930           0      0.41938E+09
RA1620       20929       20930      0.53870E-02
VA1620       20928       20929 AC   0.00000E+00
LA1620       20927       20928      0.12767E-08
CA1621       20933           0      0.94876E-15
RA1621       20933           0      0.41938E+09
RA1622       20932       20933      0.53870E-02
VA1622       20931       20932 AC   0.00000E+00
LA1622       20930       20931      0.12767E-08
CA1623       20936           0      0.94876E-15
RA1623       20936           0      0.41938E+09
RA1624       20935       20936      0.53870E-02
VA1624       20934       20935 AC   0.00000E+00
LA1624       20933       20934      0.12767E-08
CA1625       20939           0      0.94876E-15
RA1625       20939           0      0.41938E+09
RA1626       20938       20939      0.53870E-02
VA1626       20937       20938 AC   0.00000E+00
LA1626       20936       20937      0.12767E-08
CA1627       20942           0      0.94876E-15
RA1627       20942           0      0.41938E+09
RA1628       20941       20942      0.53870E-02
VA1628       20940       20941 AC   0.00000E+00
LA1628       20939       20940      0.12767E-08
CA1629       20945           0      0.94876E-15
RA1629       20945           0      0.41938E+09
RA1630       20944       20945      0.53870E-02
VA1630       20943       20944 AC   0.00000E+00
LA1630       20942       20943      0.12767E-08
CA1631       20948           0      0.94876E-15
RA1631       20948           0      0.41938E+09
RA1632       20947       20948      0.53870E-02
VA1632       20946       20947 AC   0.00000E+00
LA1632       20945       20946      0.12767E-08
CA1633       20951           0      0.94876E-15
RA1633       20951           0      0.41938E+09
RA1634       20950       20951      0.53870E-02
VA1634       20949       20950 AC   0.00000E+00
LA1634       20948       20949      0.12767E-08
CA1635       20954           0      0.94876E-15
RA1635       20954           0      0.41938E+09
RA1636       20953       20954      0.53870E-02
VA1636       20952       20953 AC   0.00000E+00
LA1636       20951       20952      0.12767E-08
CA1637       20957           0      0.94876E-15
RA1637       20957           0      0.41938E+09
RA1638       20956       20957      0.53870E-02
VA1638       20955       20956 AC   0.00000E+00
LA1638       20954       20955      0.12767E-08
CA1639       20960           0      0.94876E-15
RA1639       20960           0      0.41938E+09
RA1640       20959       20960      0.53870E-02
VA1640       20958       20959 AC   0.00000E+00
LA1640       20957       20958      0.12767E-08
CA1641       20963           0      0.94876E-15
RA1641       20963           0      0.41938E+09
RA1642       20962       20963      0.53870E-02
VA1642       20961       20962 AC   0.00000E+00
LA1642       20960       20961      0.12767E-08
CA1643       20966           0      0.18149E-14
RA1643       20966           0      0.41938E+09
RA1644       20965       20966      0.53870E-02
VA1644       20964       20965 AC   0.00000E+00
LA1644       20963       20964      0.12767E-08
RA1645           0       20967      0.26935E-02
VA1645       20967       20968 AC   0.00000E+00
LA1645       20968       20969      0.63835E-09
CA1646       20969           0      0.94876E-15
RA1646       20969           0      0.41938E+09
CA1647       20972           0      0.94876E-15
RA1647       20972           0      0.41938E+09
RA1648       20971       20972      0.53870E-02
VA1648       20970       20971 AC   0.00000E+00
LA1648       20969       20970      0.12767E-08
CA1649       20975           0      0.94876E-15
RA1649       20975           0      0.41938E+09
RA1650       20974       20975      0.53870E-02
VA1650       20973       20974 AC   0.00000E+00
LA1650       20972       20973      0.12767E-08
CA1651       20978           0      0.94876E-15
RA1651       20978           0      0.41938E+09
RA1652       20977       20978      0.53870E-02
VA1652       20976       20977 AC   0.00000E+00
LA1652       20975       20976      0.12767E-08
CA1653       20981           0      0.94876E-15
RA1653       20981           0      0.41938E+09
RA1654       20980       20981      0.53870E-02
VA1654       20979       20980 AC   0.00000E+00
LA1654       20978       20979      0.12767E-08
CA1655       20984           0      0.94876E-15
RA1655       20984           0      0.41938E+09
RA1656       20983       20984      0.53870E-02
VA1656       20982       20983 AC   0.00000E+00
LA1656       20981       20982      0.12767E-08
CA1657       20987           0      0.94876E-15
RA1657       20987           0      0.41938E+09
RA1658       20986       20987      0.53870E-02
VA1658       20985       20986 AC   0.00000E+00
LA1658       20984       20985      0.12767E-08
CA1659       20990           0      0.94876E-15
RA1659       20990           0      0.41938E+09
RA1660       20989       20990      0.53870E-02
VA1660       20988       20989 AC   0.00000E+00
LA1660       20987       20988      0.12767E-08
CA1661       20993           0      0.94876E-15
RA1661       20993           0      0.41938E+09
RA1662       20992       20993      0.53870E-02
VA1662       20991       20992 AC   0.00000E+00
LA1662       20990       20991      0.12767E-08
CA1663       20996           0      0.94876E-15
RA1663       20996           0      0.41938E+09
RA1664       20995       20996      0.53870E-02
VA1664       20994       20995 AC   0.00000E+00
LA1664       20993       20994      0.12767E-08
CA1665       20999           0      0.94876E-15
RA1665       20999           0      0.41938E+09
RA1666       20998       20999      0.53870E-02
VA1666       20997       20998 AC   0.00000E+00
LA1666       20996       20997      0.12767E-08
CA1667       21002           0      0.94876E-15
RA1667       21002           0      0.41938E+09
RA1668       21001       21002      0.53870E-02
VA1668       21000       21001 AC   0.00000E+00
LA1668       20999       21000      0.12767E-08
CA1669       21005           0      0.94876E-15
RA1669       21005           0      0.41938E+09
RA1670       21004       21005      0.53870E-02
VA1670       21003       21004 AC   0.00000E+00
LA1670       21002       21003      0.12767E-08
CA1671       21008           0      0.94876E-15
RA1671       21008           0      0.41938E+09
RA1672       21007       21008      0.53870E-02
VA1672       21006       21007 AC   0.00000E+00
LA1672       21005       21006      0.12767E-08
CA1673       21011           0      0.94876E-15
RA1673       21011           0      0.41938E+09
RA1674       21010       21011      0.53870E-02
VA1674       21009       21010 AC   0.00000E+00
LA1674       21008       21009      0.12767E-08
CA1675       21014           0      0.94876E-15
RA1675       21014           0      0.41938E+09
RA1676       21013       21014      0.53870E-02
VA1676       21012       21013 AC   0.00000E+00
LA1676       21011       21012      0.12767E-08
CA1677       21017           0      0.94876E-15
RA1677       21017           0      0.41938E+09
RA1678       21016       21017      0.53870E-02
VA1678       21015       21016 AC   0.00000E+00
LA1678       21014       21015      0.12767E-08
CA1679       21020           0      0.94876E-15
RA1679       21020           0      0.41938E+09
RA1680       21019       21020      0.53870E-02
VA1680       21018       21019 AC   0.00000E+00
LA1680       21017       21018      0.12767E-08
CA1681       21023           0      0.94876E-15
RA1681       21023           0      0.41938E+09
RA1682       21022       21023      0.53870E-02
VA1682       21021       21022 AC   0.00000E+00
LA1682       21020       21021      0.12767E-08
CA1683       21026           0      0.94876E-15
RA1683       21026           0      0.41938E+09
RA1684       21025       21026      0.53870E-02
VA1684       21024       21025 AC   0.00000E+00
LA1684       21023       21024      0.12767E-08
CA1685       21029           0      0.49648E-14
RA1685       21029           0      0.41938E+09
RA1686       21028       21029      0.53870E-02
VA1686       21027       21028 AC   0.00000E+00
LA1686       21026       21027      0.71000E-09
CA1687       21032           0      0.49648E-14
RA1687       21032           0      0.41938E+09
RA1688       21031       21032      0.53870E-02
VA1688       21030       21031 AC   0.00000E+00
LA1688       21029       21030      0.14329E-09
CA1689       21035           0      0.49648E-14
RA1689       21035           0      0.41938E+09
RA1690       21034       21035      0.53870E-02
VA1690       21033       21034 AC   0.00000E+00
LA1690       21032       21033      0.14329E-09
CA1691       21038           0      0.49648E-14
RA1691       21038           0      0.41938E+09
RA1692       21037       21038      0.53870E-02
VA1692       21036       21037 AC   0.00000E+00
LA1692       21035       21036      0.14329E-09
CA1693       21041           0      0.49648E-14
RA1693       21041           0      0.41938E+09
RA1694       21040       21041      0.53870E-02
VA1694       21039       21040 AC   0.00000E+00
LA1694       21038       21039      0.14329E-09
CA1695       21044           0      0.49648E-14
RA1695       21044           0      0.41938E+09
RA1696       21043       21044      0.53870E-02
VA1696       21042       21043 AC   0.00000E+00
LA1696       21041       21042      0.14329E-09
CA1697       21047           0      0.49648E-14
RA1697       21047           0      0.41938E+09
RA1698       21046       21047      0.53870E-02
VA1698       21045       21046 AC   0.00000E+00
LA1698       21044       21045      0.14329E-09
CA1699       21050           0      0.49648E-14
RA1699       21050           0      0.41938E+09
RA1700       21049       21050      0.53870E-02
VA1700       21048       21049 AC   0.00000E+00
LA1700       21047       21048      0.14329E-09
CA1701       21053           0      0.49648E-14
RA1701       21053           0      0.41938E+09
RA1702       21052       21053      0.53870E-02
VA1702       21051       21052 AC   0.00000E+00
LA1702       21050       21051      0.14329E-09
CA1703       21056           0      0.49648E-14
RA1703       21056           0      0.41938E+09
RA1704       21055       21056      0.53870E-02
VA1704       21054       21055 AC   0.00000E+00
LA1704       21053       21054      0.14329E-09
CA1705       21059           0      0.49648E-14
RA1705       21059           0      0.41938E+09
RA1706       21058       21059      0.53870E-02
VA1706       21057       21058 AC   0.00000E+00
LA1706       21056       21057      0.14329E-09
CA1707       21062           0      0.49648E-14
RA1707       21062           0      0.41938E+09
RA1708       21061       21062      0.53870E-02
VA1708       21060       21061 AC   0.00000E+00
LA1708       21059       21060      0.14329E-09
CA1709       21065           0      0.94876E-15
RA1709       21065           0      0.41938E+09
RA1710       21064       21065      0.53870E-02
VA1710       21063       21064 AC   0.00000E+00
LA1710       21062       21063      0.71000E-09
CA1711       21068           0      0.94876E-15
RA1711       21068           0      0.41938E+09
RA1712       21067       21068      0.53870E-02
VA1712       21066       21067 AC   0.00000E+00
LA1712       21065       21066      0.12767E-08
CA1713       21071           0      0.94876E-15
RA1713       21071           0      0.41938E+09
RA1714       21070       21071      0.53870E-02
VA1714       21069       21070 AC   0.00000E+00
LA1714       21068       21069      0.12767E-08
CA1715       21074           0      0.94876E-15
RA1715       21074           0      0.41938E+09
RA1716       21073       21074      0.53870E-02
VA1716       21072       21073 AC   0.00000E+00
LA1716       21071       21072      0.12767E-08
CA1717       21077           0      0.94876E-15
RA1717       21077           0      0.41938E+09
RA1718       21076       21077      0.53870E-02
VA1718       21075       21076 AC   0.00000E+00
LA1718       21074       21075      0.12767E-08
CA1719       21080           0      0.94876E-15
RA1719       21080           0      0.41938E+09
RA1720       21079       21080      0.53870E-02
VA1720       21078       21079 AC   0.00000E+00
LA1720       21077       21078      0.12767E-08
CA1721       21083           0      0.94876E-15
RA1721       21083           0      0.41938E+09
RA1722       21082       21083      0.53870E-02
VA1722       21081       21082 AC   0.00000E+00
LA1722       21080       21081      0.12767E-08
CA1723       21086           0      0.94876E-15
RA1723       21086           0      0.41938E+09
RA1724       21085       21086      0.53870E-02
VA1724       21084       21085 AC   0.00000E+00
LA1724       21083       21084      0.12767E-08
CA1725       21089           0      0.94876E-15
RA1725       21089           0      0.41938E+09
RA1726       21088       21089      0.53870E-02
VA1726       21087       21088 AC   0.00000E+00
LA1726       21086       21087      0.12767E-08
CA1727       21092           0      0.94876E-15
RA1727       21092           0      0.41938E+09
RA1728       21091       21092      0.53870E-02
VA1728       21090       21091 AC   0.00000E+00
LA1728       21089       21090      0.12767E-08
CA1729       21095           0      0.94876E-15
RA1729       21095           0      0.41938E+09
RA1730       21094       21095      0.53870E-02
VA1730       21093       21094 AC   0.00000E+00
LA1730       21092       21093      0.12767E-08
CA1731       21098           0      0.94876E-15
RA1731       21098           0      0.41938E+09
RA1732       21097       21098      0.53870E-02
VA1732       21096       21097 AC   0.00000E+00
LA1732       21095       21096      0.12767E-08
CA1733       21101           0      0.94876E-15
RA1733       21101           0      0.41938E+09
RA1734       21100       21101      0.53870E-02
VA1734       21099       21100 AC   0.00000E+00
LA1734       21098       21099      0.12767E-08
CA1735       21104           0      0.18149E-14
RA1735       21104           0      0.41938E+09
RA1736       21103       21104      0.53870E-02
VA1736       21102       21103 AC   0.00000E+00
LA1736       21101       21102      0.12767E-08
RA1737           0       21105      0.26935E-02
VA1737       21105       21106 AC   0.00000E+00
LA1737       21106       21107      0.63835E-09
CA1738       21107           0      0.94876E-15
RA1738       21107           0      0.41938E+09
CA1739       21110           0      0.94876E-15
RA1739       21110           0      0.41938E+09
RA1740       21109       21110      0.53870E-02
VA1740       21108       21109 AC   0.00000E+00
LA1740       21107       21108      0.12767E-08
CA1741       21113           0      0.94876E-15
RA1741       21113           0      0.41938E+09
RA1742       21112       21113      0.53870E-02
VA1742       21111       21112 AC   0.00000E+00
LA1742       21110       21111      0.12767E-08
CA1743       21116           0      0.94876E-15
RA1743       21116           0      0.41938E+09
RA1744       21115       21116      0.53870E-02
VA1744       21114       21115 AC   0.00000E+00
LA1744       21113       21114      0.12767E-08
CA1745       21119           0      0.94876E-15
RA1745       21119           0      0.41938E+09
RA1746       21118       21119      0.53870E-02
VA1746       21117       21118 AC   0.00000E+00
LA1746       21116       21117      0.12767E-08
CA1747       21122           0      0.94876E-15
RA1747       21122           0      0.41938E+09
RA1748       21121       21122      0.53870E-02
VA1748       21120       21121 AC   0.00000E+00
LA1748       21119       21120      0.12767E-08
CA1749       21125           0      0.94876E-15
RA1749       21125           0      0.41938E+09
RA1750       21124       21125      0.53870E-02
VA1750       21123       21124 AC   0.00000E+00
LA1750       21122       21123      0.12767E-08
CA1751       21128           0      0.94876E-15
RA1751       21128           0      0.41938E+09
RA1752       21127       21128      0.53870E-02
VA1752       21126       21127 AC   0.00000E+00
LA1752       21125       21126      0.12767E-08
CA1753       21131           0      0.94876E-15
RA1753       21131           0      0.41938E+09
RA1754       21130       21131      0.53870E-02
VA1754       21129       21130 AC   0.00000E+00
LA1754       21128       21129      0.12767E-08
CA1755       21134           0      0.94876E-15
RA1755       21134           0      0.41938E+09
RA1756       21133       21134      0.53870E-02
VA1756       21132       21133 AC   0.00000E+00
LA1756       21131       21132      0.12767E-08
CA1757       21137           0      0.94876E-15
RA1757       21137           0      0.41938E+09
RA1758       21136       21137      0.53870E-02
VA1758       21135       21136 AC   0.00000E+00
LA1758       21134       21135      0.12767E-08
CA1759       21140           0      0.94876E-15
RA1759       21140           0      0.41938E+09
RA1760       21139       21140      0.53870E-02
VA1760       21138       21139 AC   0.00000E+00
LA1760       21137       21138      0.12767E-08
CA1761       21143           0      0.94876E-15
RA1761       21143           0      0.41938E+09
RA1762       21142       21143      0.53870E-02
VA1762       21141       21142 AC   0.00000E+00
LA1762       21140       21141      0.12767E-08
CA1763       21146           0      0.94876E-15
RA1763       21146           0      0.41938E+09
RA1764       21145       21146      0.53870E-02
VA1764       21144       21145 AC   0.00000E+00
LA1764       21143       21144      0.12767E-08
CA1765       21149           0      0.94876E-15
RA1765       21149           0      0.41938E+09
RA1766       21148       21149      0.53870E-02
VA1766       21147       21148 AC   0.00000E+00
LA1766       21146       21147      0.12767E-08
CA1767       21152           0      0.94876E-15
RA1767       21152           0      0.41938E+09
RA1768       21151       21152      0.53870E-02
VA1768       21150       21151 AC   0.00000E+00
LA1768       21149       21150      0.12767E-08
CA1769       21155           0      0.94876E-15
RA1769       21155           0      0.41938E+09
RA1770       21154       21155      0.53870E-02
VA1770       21153       21154 AC   0.00000E+00
LA1770       21152       21153      0.12767E-08
CA1771       21158           0      0.94876E-15
RA1771       21158           0      0.41938E+09
RA1772       21157       21158      0.53870E-02
VA1772       21156       21157 AC   0.00000E+00
LA1772       21155       21156      0.12767E-08
CA1773       21161           0      0.94876E-15
RA1773       21161           0      0.41938E+09
RA1774       21160       21161      0.53870E-02
VA1774       21159       21160 AC   0.00000E+00
LA1774       21158       21159      0.12767E-08
CA1775       21164           0      0.51451E-14
RA1775       21164           0      0.41938E+09
RA1776       21163       21164      0.53870E-02
VA1776       21162       21163 AC   0.00000E+00
LA1776       21161       21162      0.12767E-08
CA1777       21165           0      0.50868E-14
RA1777       21165           0      0.41938E+09
CA1778       21168           0      0.94876E-15
RA1778       21168           0      0.41938E+09
RA1779       21167       21168      0.53870E-02
VA1779       21166       21167 AC   0.00000E+00
LA1779       21165       21166      0.12767E-08
CA1780       21171           0      0.94876E-15
RA1780       21171           0      0.41938E+09
RA1781       21170       21171      0.53870E-02
VA1781       21169       21170 AC   0.00000E+00
LA1781       21168       21169      0.12767E-08
CA1782       21174           0      0.94876E-15
RA1782       21174           0      0.41938E+09
RA1783       21173       21174      0.53870E-02
VA1783       21172       21173 AC   0.00000E+00
LA1783       21171       21172      0.12767E-08
CA1784       21177           0      0.94876E-15
RA1784       21177           0      0.41938E+09
RA1785       21176       21177      0.53870E-02
VA1785       21175       21176 AC   0.00000E+00
LA1785       21174       21175      0.12767E-08
CA1786       21180           0      0.94876E-15
RA1786       21180           0      0.41938E+09
RA1787       21179       21180      0.53870E-02
VA1787       21178       21179 AC   0.00000E+00
LA1787       21177       21178      0.12767E-08
CA1788       21183           0      0.94876E-15
RA1788       21183           0      0.41938E+09
RA1789       21182       21183      0.53870E-02
VA1789       21181       21182 AC   0.00000E+00
LA1789       21180       21181      0.12767E-08
CA1790       21186           0      0.94876E-15
RA1790       21186           0      0.41938E+09
RA1791       21185       21186      0.53870E-02
VA1791       21184       21185 AC   0.00000E+00
LA1791       21183       21184      0.12767E-08
CA1792       21189           0      0.94876E-15
RA1792       21189           0      0.41938E+09
RA1793       21188       21189      0.53870E-02
VA1793       21187       21188 AC   0.00000E+00
LA1793       21186       21187      0.12767E-08
CA1794       21192           0      0.94876E-15
RA1794       21192           0      0.41938E+09
RA1795       21191       21192      0.53870E-02
VA1795       21190       21191 AC   0.00000E+00
LA1795       21189       21190      0.12767E-08
CA1796       21195           0      0.94876E-15
RA1796       21195           0      0.41938E+09
RA1797       21194       21195      0.53870E-02
VA1797       21193       21194 AC   0.00000E+00
LA1797       21192       21193      0.12767E-08
CA1798       21198           0      0.94876E-15
RA1798       21198           0      0.41938E+09
RA1799       21197       21198      0.53870E-02
VA1799       21196       21197 AC   0.00000E+00
LA1799       21195       21196      0.12767E-08
CA1800       21201           0      0.94876E-15
RA1800       21201           0      0.41938E+09
RA1801       21200       21201      0.53870E-02
VA1801       21199       21200 AC   0.00000E+00
LA1801       21198       21199      0.12767E-08
CA1802       21204           0      0.16377E-14
RA1802       21204           0      0.41938E+09
RA1803       21203       21204      0.53870E-02
VA1803       21202       21203 AC   0.00000E+00
LA1803       21201       21202      0.12767E-08
RA1804           0       21205      0.26935E-02
VA1804       21205       21206 AC   0.00000E+00
LA1804       21206       21207      0.63835E-09
CA1805       21207           0      0.94876E-15
RA1805       21207           0      0.41938E+09
CA1806       21210           0      0.94876E-15
RA1806       21210           0      0.41938E+09
RA1807       21209       21210      0.53870E-02
VA1807       21208       21209 AC   0.00000E+00
LA1807       21207       21208      0.12767E-08
CA1808       21213           0      0.94876E-15
RA1808       21213           0      0.41938E+09
RA1809       21212       21213      0.53870E-02
VA1809       21211       21212 AC   0.00000E+00
LA1809       21210       21211      0.12767E-08
CA1810       21216           0      0.94876E-15
RA1810       21216           0      0.41938E+09
RA1811       21215       21216      0.53870E-02
VA1811       21214       21215 AC   0.00000E+00
LA1811       21213       21214      0.12767E-08
CA1812       21219           0      0.94876E-15
RA1812       21219           0      0.41938E+09
RA1813       21218       21219      0.53870E-02
VA1813       21217       21218 AC   0.00000E+00
LA1813       21216       21217      0.12767E-08
CA1814       21222           0      0.94876E-15
RA1814       21222           0      0.41938E+09
RA1815       21221       21222      0.53870E-02
VA1815       21220       21221 AC   0.00000E+00
LA1815       21219       21220      0.12767E-08
CA1816       21225           0      0.94876E-15
RA1816       21225           0      0.41938E+09
RA1817       21224       21225      0.53870E-02
VA1817       21223       21224 AC   0.00000E+00
LA1817       21222       21223      0.12767E-08
CA1818       21228           0      0.94876E-15
RA1818       21228           0      0.41938E+09
RA1819       21227       21228      0.53870E-02
VA1819       21226       21227 AC   0.00000E+00
LA1819       21225       21226      0.12767E-08
CA1820       21231           0      0.94876E-15
RA1820       21231           0      0.41938E+09
RA1821       21230       21231      0.53870E-02
VA1821       21229       21230 AC   0.00000E+00
LA1821       21228       21229      0.12767E-08
CA1822       21234           0      0.94876E-15
RA1822       21234           0      0.41938E+09
RA1823       21233       21234      0.53870E-02
VA1823       21232       21233 AC   0.00000E+00
LA1823       21231       21232      0.12767E-08
CA1824       21237           0      0.94876E-15
RA1824       21237           0      0.41938E+09
RA1825       21236       21237      0.53870E-02
VA1825       21235       21236 AC   0.00000E+00
LA1825       21234       21235      0.12767E-08
CA1826       21240           0      0.94876E-15
RA1826       21240           0      0.41938E+09
RA1827       21239       21240      0.53870E-02
VA1827       21238       21239 AC   0.00000E+00
LA1827       21237       21238      0.12767E-08
CA1828       21243           0      0.94876E-15
RA1828       21243           0      0.41938E+09
RA1829       21242       21243      0.53870E-02
VA1829       21241       21242 AC   0.00000E+00
LA1829       21240       21241      0.12767E-08
CA1830       21246           0      0.94876E-15
RA1830       21246           0      0.41938E+09
RA1831       21245       21246      0.53870E-02
VA1831       21244       21245 AC   0.00000E+00
LA1831       21243       21244      0.12767E-08
CA1832       21249           0      0.94876E-15
RA1832       21249           0      0.41938E+09
RA1833       21248       21249      0.53870E-02
VA1833       21247       21248 AC   0.00000E+00
LA1833       21246       21247      0.12767E-08
CA1834       21252           0      0.94876E-15
RA1834       21252           0      0.41938E+09
RA1835       21251       21252      0.53870E-02
VA1835       21250       21251 AC   0.00000E+00
LA1835       21249       21250      0.12767E-08
CA1836       21255           0      0.94876E-15
RA1836       21255           0      0.41938E+09
RA1837       21254       21255      0.53870E-02
VA1837       21253       21254 AC   0.00000E+00
LA1837       21252       21253      0.12767E-08
CA1838       21258           0      0.94876E-15
RA1838       21258           0      0.41938E+09
RA1839       21257       21258      0.53870E-02
VA1839       21256       21257 AC   0.00000E+00
LA1839       21255       21256      0.12767E-08
CA1840       21261           0      0.94876E-15
RA1840       21261           0      0.41938E+09
RA1841       21260       21261      0.53870E-02
VA1841       21259       21260 AC   0.00000E+00
LA1841       21258       21259      0.12767E-08
CA1842       21264           0      0.51451E-14
RA1842       21264           0      0.41938E+09
RA1843       21263       21264      0.53870E-02
VA1843       21262       21263 AC   0.00000E+00
LA1843       21261       21262      0.12767E-08
CA1844       21265           0      0.50868E-14
RA1844       21265           0      0.41938E+09
CA1845       21268           0      0.94876E-15
RA1845       21268           0      0.41938E+09
RA1846       21267       21268      0.53870E-02
VA1846       21266       21267 AC   0.00000E+00
LA1846       21265       21266      0.12767E-08
CA1847       21271           0      0.94876E-15
RA1847       21271           0      0.41938E+09
RA1848       21270       21271      0.53870E-02
VA1848       21269       21270 AC   0.00000E+00
LA1848       21268       21269      0.12767E-08
CA1849       21274           0      0.94876E-15
RA1849       21274           0      0.41938E+09
RA1850       21273       21274      0.53870E-02
VA1850       21272       21273 AC   0.00000E+00
LA1850       21271       21272      0.12767E-08
CA1851       21277           0      0.94876E-15
RA1851       21277           0      0.41938E+09
RA1852       21276       21277      0.53870E-02
VA1852       21275       21276 AC   0.00000E+00
LA1852       21274       21275      0.12767E-08
CA1853       21280           0      0.94876E-15
RA1853       21280           0      0.41938E+09
RA1854       21279       21280      0.53870E-02
VA1854       21278       21279 AC   0.00000E+00
LA1854       21277       21278      0.12767E-08
CA1855       21283           0      0.94876E-15
RA1855       21283           0      0.41938E+09
RA1856       21282       21283      0.53870E-02
VA1856       21281       21282 AC   0.00000E+00
LA1856       21280       21281      0.12767E-08
CA1857       21286           0      0.94876E-15
RA1857       21286           0      0.41938E+09
RA1858       21285       21286      0.53870E-02
VA1858       21284       21285 AC   0.00000E+00
LA1858       21283       21284      0.12767E-08
CA1859       21289           0      0.94876E-15
RA1859       21289           0      0.41938E+09
RA1860       21288       21289      0.53870E-02
VA1860       21287       21288 AC   0.00000E+00
LA1860       21286       21287      0.12767E-08
CA1861       21292           0      0.94876E-15
RA1861       21292           0      0.41938E+09
RA1862       21291       21292      0.53870E-02
VA1862       21290       21291 AC   0.00000E+00
LA1862       21289       21290      0.12767E-08
CA1863       21295           0      0.94876E-15
RA1863       21295           0      0.41938E+09
RA1864       21294       21295      0.53870E-02
VA1864       21293       21294 AC   0.00000E+00
LA1864       21292       21293      0.12767E-08
CA1865       21298           0      0.94876E-15
RA1865       21298           0      0.41938E+09
RA1866       21297       21298      0.53870E-02
VA1866       21296       21297 AC   0.00000E+00
LA1866       21295       21296      0.12767E-08
CA1867       21301           0      0.94876E-15
RA1867       21301           0      0.41938E+09
RA1868       21300       21301      0.53870E-02
VA1868       21299       21300 AC   0.00000E+00
LA1868       21298       21299      0.12767E-08
CA1869       21304           0      0.16377E-14
RA1869       21304           0      0.41938E+09
RA1870       21303       21304      0.53870E-02
VA1870       21302       21303 AC   0.00000E+00
LA1870       21301       21302      0.12767E-08
RA1871           0       21305      0.26935E-02
VA1871       21305       21306 AC   0.00000E+00
LA1871       21306       21307      0.63835E-09
CA1872       21307           0      0.94876E-15
RA1872       21307           0      0.41938E+09
CA1873       21310           0      0.94876E-15
RA1873       21310           0      0.41938E+09
RA1874       21309       21310      0.53870E-02
VA1874       21308       21309 AC   0.00000E+00
LA1874       21307       21308      0.12767E-08
CA1875       21313           0      0.94876E-15
RA1875       21313           0      0.41938E+09
RA1876       21312       21313      0.53870E-02
VA1876       21311       21312 AC   0.00000E+00
LA1876       21310       21311      0.12767E-08
CA1877       21316           0      0.94876E-15
RA1877       21316           0      0.41938E+09
RA1878       21315       21316      0.53870E-02
VA1878       21314       21315 AC   0.00000E+00
LA1878       21313       21314      0.12767E-08
CA1879       21319           0      0.94876E-15
RA1879       21319           0      0.41938E+09
RA1880       21318       21319      0.53870E-02
VA1880       21317       21318 AC   0.00000E+00
LA1880       21316       21317      0.12767E-08
CA1881       21322           0      0.94876E-15
RA1881       21322           0      0.41938E+09
RA1882       21321       21322      0.53870E-02
VA1882       21320       21321 AC   0.00000E+00
LA1882       21319       21320      0.12767E-08
CA1883       21325           0      0.94876E-15
RA1883       21325           0      0.41938E+09
RA1884       21324       21325      0.53870E-02
VA1884       21323       21324 AC   0.00000E+00
LA1884       21322       21323      0.12767E-08
CA1885       21328           0      0.94876E-15
RA1885       21328           0      0.41938E+09
RA1886       21327       21328      0.53870E-02
VA1886       21326       21327 AC   0.00000E+00
LA1886       21325       21326      0.12767E-08
CA1887       21331           0      0.94876E-15
RA1887       21331           0      0.41938E+09
RA1888       21330       21331      0.53870E-02
VA1888       21329       21330 AC   0.00000E+00
LA1888       21328       21329      0.12767E-08
CA1889       21334           0      0.94876E-15
RA1889       21334           0      0.41938E+09
RA1890       21333       21334      0.53870E-02
VA1890       21332       21333 AC   0.00000E+00
LA1890       21331       21332      0.12767E-08
CA1891       21337           0      0.94876E-15
RA1891       21337           0      0.41938E+09
RA1892       21336       21337      0.53870E-02
VA1892       21335       21336 AC   0.00000E+00
LA1892       21334       21335      0.12767E-08
CA1893       21340           0      0.94876E-15
RA1893       21340           0      0.41938E+09
RA1894       21339       21340      0.53870E-02
VA1894       21338       21339 AC   0.00000E+00
LA1894       21337       21338      0.12767E-08
CA1895       21343           0      0.94876E-15
RA1895       21343           0      0.41938E+09
RA1896       21342       21343      0.53870E-02
VA1896       21341       21342 AC   0.00000E+00
LA1896       21340       21341      0.12767E-08
CA1897       21346           0      0.94876E-15
RA1897       21346           0      0.41938E+09
RA1898       21345       21346      0.53870E-02
VA1898       21344       21345 AC   0.00000E+00
LA1898       21343       21344      0.12767E-08
CA1899       21349           0      0.94876E-15
RA1899       21349           0      0.41938E+09
RA1900       21348       21349      0.53870E-02
VA1900       21347       21348 AC   0.00000E+00
LA1900       21346       21347      0.12767E-08
CA1901       21352           0      0.94876E-15
RA1901       21352           0      0.41938E+09
RA1902       21351       21352      0.53870E-02
VA1902       21350       21351 AC   0.00000E+00
LA1902       21349       21350      0.12767E-08
CA1903       21355           0      0.94876E-15
RA1903       21355           0      0.41938E+09
RA1904       21354       21355      0.53870E-02
VA1904       21353       21354 AC   0.00000E+00
LA1904       21352       21353      0.12767E-08
CA1905       21358           0      0.94876E-15
RA1905       21358           0      0.41938E+09
RA1906       21357       21358      0.53870E-02
VA1906       21356       21357 AC   0.00000E+00
LA1906       21355       21356      0.12767E-08
CA1907       21361           0      0.94876E-15
RA1907       21361           0      0.41938E+09
RA1908       21360       21361      0.53870E-02
VA1908       21359       21360 AC   0.00000E+00
LA1908       21358       21359      0.12767E-08
CA1909       21364           0      0.51451E-14
RA1909       21364           0      0.41938E+09
RA1910       21363       21364      0.53870E-02
VA1910       21362       21363 AC   0.00000E+00
LA1910       21361       21362      0.12767E-08
CA1911       21365           0      0.50868E-14
RA1911       21365           0      0.41938E+09
CA1912       21368           0      0.94876E-15
RA1912       21368           0      0.41938E+09
RA1913       21367       21368      0.53870E-02
VA1913       21366       21367 AC   0.00000E+00
LA1913       21365       21366      0.12767E-08
CA1914       21371           0      0.94876E-15
RA1914       21371           0      0.41938E+09
RA1915       21370       21371      0.53870E-02
VA1915       21369       21370 AC   0.00000E+00
LA1915       21368       21369      0.12767E-08
CA1916       21374           0      0.94876E-15
RA1916       21374           0      0.41938E+09
RA1917       21373       21374      0.53870E-02
VA1917       21372       21373 AC   0.00000E+00
LA1917       21371       21372      0.12767E-08
CA1918       21377           0      0.94876E-15
RA1918       21377           0      0.41938E+09
RA1919       21376       21377      0.53870E-02
VA1919       21375       21376 AC   0.00000E+00
LA1919       21374       21375      0.12767E-08
CA1920       21380           0      0.94876E-15
RA1920       21380           0      0.41938E+09
RA1921       21379       21380      0.53870E-02
VA1921       21378       21379 AC   0.00000E+00
LA1921       21377       21378      0.12767E-08
CA1922       21383           0      0.94876E-15
RA1922       21383           0      0.41938E+09
RA1923       21382       21383      0.53870E-02
VA1923       21381       21382 AC   0.00000E+00
LA1923       21380       21381      0.12767E-08
CA1924       21386           0      0.94876E-15
RA1924       21386           0      0.41938E+09
RA1925       21385       21386      0.53870E-02
VA1925       21384       21385 AC   0.00000E+00
LA1925       21383       21384      0.12767E-08
CA1926       21389           0      0.94876E-15
RA1926       21389           0      0.41938E+09
RA1927       21388       21389      0.53870E-02
VA1927       21387       21388 AC   0.00000E+00
LA1927       21386       21387      0.12767E-08
CA1928       21392           0      0.94876E-15
RA1928       21392           0      0.41938E+09
RA1929       21391       21392      0.53870E-02
VA1929       21390       21391 AC   0.00000E+00
LA1929       21389       21390      0.12767E-08
CA1930       21395           0      0.94876E-15
RA1930       21395           0      0.41938E+09
RA1931       21394       21395      0.53870E-02
VA1931       21393       21394 AC   0.00000E+00
LA1931       21392       21393      0.12767E-08
CA1932       21398           0      0.94876E-15
RA1932       21398           0      0.41938E+09
RA1933       21397       21398      0.53870E-02
VA1933       21396       21397 AC   0.00000E+00
LA1933       21395       21396      0.12767E-08
CA1934       21401           0      0.94876E-15
RA1934       21401           0      0.41938E+09
RA1935       21400       21401      0.53870E-02
VA1935       21399       21400 AC   0.00000E+00
LA1935       21398       21399      0.12767E-08
CA1936       21404           0      0.16377E-14
RA1936       21404           0      0.41938E+09
RA1937       21403       21404      0.53870E-02
VA1937       21402       21403 AC   0.00000E+00
LA1937       21401       21402      0.12767E-08
RA1938           0       21405      0.26935E-02
VA1938       21405       21406 AC   0.00000E+00
LA1938       21406       21407      0.63835E-09
CA1939       21407           0      0.94876E-15
RA1939       21407           0      0.41938E+09
CA1940       21410           0      0.94876E-15
RA1940       21410           0      0.41938E+09
RA1941       21409       21410      0.53870E-02
VA1941       21408       21409 AC   0.00000E+00
LA1941       21407       21408      0.12767E-08
CA1942       21413           0      0.94876E-15
RA1942       21413           0      0.41938E+09
RA1943       21412       21413      0.53870E-02
VA1943       21411       21412 AC   0.00000E+00
LA1943       21410       21411      0.12767E-08
CA1944       21416           0      0.94876E-15
RA1944       21416           0      0.41938E+09
RA1945       21415       21416      0.53870E-02
VA1945       21414       21415 AC   0.00000E+00
LA1945       21413       21414      0.12767E-08
CA1946       21419           0      0.94876E-15
RA1946       21419           0      0.41938E+09
RA1947       21418       21419      0.53870E-02
VA1947       21417       21418 AC   0.00000E+00
LA1947       21416       21417      0.12767E-08
CA1948       21422           0      0.94876E-15
RA1948       21422           0      0.41938E+09
RA1949       21421       21422      0.53870E-02
VA1949       21420       21421 AC   0.00000E+00
LA1949       21419       21420      0.12767E-08
CA1950       21425           0      0.94876E-15
RA1950       21425           0      0.41938E+09
RA1951       21424       21425      0.53870E-02
VA1951       21423       21424 AC   0.00000E+00
LA1951       21422       21423      0.12767E-08
CA1952       21428           0      0.94876E-15
RA1952       21428           0      0.41938E+09
RA1953       21427       21428      0.53870E-02
VA1953       21426       21427 AC   0.00000E+00
LA1953       21425       21426      0.12767E-08
CA1954       21431           0      0.94876E-15
RA1954       21431           0      0.41938E+09
RA1955       21430       21431      0.53870E-02
VA1955       21429       21430 AC   0.00000E+00
LA1955       21428       21429      0.12767E-08
CA1956       21434           0      0.94876E-15
RA1956       21434           0      0.41938E+09
RA1957       21433       21434      0.53870E-02
VA1957       21432       21433 AC   0.00000E+00
LA1957       21431       21432      0.12767E-08
CA1958       21437           0      0.94876E-15
RA1958       21437           0      0.41938E+09
RA1959       21436       21437      0.53870E-02
VA1959       21435       21436 AC   0.00000E+00
LA1959       21434       21435      0.12767E-08
CA1960       21440           0      0.94876E-15
RA1960       21440           0      0.41938E+09
RA1961       21439       21440      0.53870E-02
VA1961       21438       21439 AC   0.00000E+00
LA1961       21437       21438      0.12767E-08
CA1962       21443           0      0.94876E-15
RA1962       21443           0      0.41938E+09
RA1963       21442       21443      0.53870E-02
VA1963       21441       21442 AC   0.00000E+00
LA1963       21440       21441      0.12767E-08
CA1964       21446           0      0.94876E-15
RA1964       21446           0      0.41938E+09
RA1965       21445       21446      0.53870E-02
VA1965       21444       21445 AC   0.00000E+00
LA1965       21443       21444      0.12767E-08
CA1966       21449           0      0.94876E-15
RA1966       21449           0      0.41938E+09
RA1967       21448       21449      0.53870E-02
VA1967       21447       21448 AC   0.00000E+00
LA1967       21446       21447      0.12767E-08
CA1968       21452           0      0.94876E-15
RA1968       21452           0      0.41938E+09
RA1969       21451       21452      0.53870E-02
VA1969       21450       21451 AC   0.00000E+00
LA1969       21449       21450      0.12767E-08
CA1970       21455           0      0.94876E-15
RA1970       21455           0      0.41938E+09
RA1971       21454       21455      0.53870E-02
VA1971       21453       21454 AC   0.00000E+00
LA1971       21452       21453      0.12767E-08
CA1972       21458           0      0.94876E-15
RA1972       21458           0      0.41938E+09
RA1973       21457       21458      0.53870E-02
VA1973       21456       21457 AC   0.00000E+00
LA1973       21455       21456      0.12767E-08
CA1974       21461           0      0.94876E-15
RA1974       21461           0      0.41938E+09
RA1975       21460       21461      0.53870E-02
VA1975       21459       21460 AC   0.00000E+00
LA1975       21458       21459      0.12767E-08
CA1976       21464           0      0.51451E-14
RA1976       21464           0      0.41938E+09
RA1977       21463       21464      0.53870E-02
VA1977       21462       21463 AC   0.00000E+00
LA1977       21461       21462      0.12767E-08
CA1978       21465           0      0.50868E-14
RA1978       21465           0      0.41938E+09
CA1979       21468           0      0.94876E-15
RA1979       21468           0      0.41938E+09
RA1980       21467       21468      0.53870E-02
VA1980       21466       21467 AC   0.00000E+00
LA1980       21465       21466      0.12767E-08
CA1981       21471           0      0.94876E-15
RA1981       21471           0      0.41938E+09
RA1982       21470       21471      0.53870E-02
VA1982       21469       21470 AC   0.00000E+00
LA1982       21468       21469      0.12767E-08
CA1983       21474           0      0.94876E-15
RA1983       21474           0      0.41938E+09
RA1984       21473       21474      0.53870E-02
VA1984       21472       21473 AC   0.00000E+00
LA1984       21471       21472      0.12767E-08
CA1985       21477           0      0.94876E-15
RA1985       21477           0      0.41938E+09
RA1986       21476       21477      0.53870E-02
VA1986       21475       21476 AC   0.00000E+00
LA1986       21474       21475      0.12767E-08
CA1987       21480           0      0.94876E-15
RA1987       21480           0      0.41938E+09
RA1988       21479       21480      0.53870E-02
VA1988       21478       21479 AC   0.00000E+00
LA1988       21477       21478      0.12767E-08
CA1989       21483           0      0.94876E-15
RA1989       21483           0      0.41938E+09
RA1990       21482       21483      0.53870E-02
VA1990       21481       21482 AC   0.00000E+00
LA1990       21480       21481      0.12767E-08
CA1991       21486           0      0.94876E-15
RA1991       21486           0      0.41938E+09
RA1992       21485       21486      0.53870E-02
VA1992       21484       21485 AC   0.00000E+00
LA1992       21483       21484      0.12767E-08
CA1993       21489           0      0.94876E-15
RA1993       21489           0      0.41938E+09
RA1994       21488       21489      0.53870E-02
VA1994       21487       21488 AC   0.00000E+00
LA1994       21486       21487      0.12767E-08
CA1995       21492           0      0.94876E-15
RA1995       21492           0      0.41938E+09
RA1996       21491       21492      0.53870E-02
VA1996       21490       21491 AC   0.00000E+00
LA1996       21489       21490      0.12767E-08
CA1997       21495           0      0.94876E-15
RA1997       21495           0      0.41938E+09
RA1998       21494       21495      0.53870E-02
VA1998       21493       21494 AC   0.00000E+00
LA1998       21492       21493      0.12767E-08
CA1999       21498           0      0.94876E-15
RA1999       21498           0      0.41938E+09
RA2000       21497       21498      0.53870E-02
VA2000       21496       21497 AC   0.00000E+00
LA2000       21495       21496      0.12767E-08
CA2001       21501           0      0.94876E-15
RA2001       21501           0      0.41938E+09
RA2002       21500       21501      0.53870E-02
VA2002       21499       21500 AC   0.00000E+00
LA2002       21498       21499      0.12767E-08
CA2003       21504           0      0.16377E-14
RA2003       21504           0      0.41938E+09
RA2004       21503       21504      0.53870E-02
VA2004       21502       21503 AC   0.00000E+00
LA2004       21501       21502      0.12767E-08
RA2005           0       21505      0.26935E-02
VA2005       21505       21506 AC   0.00000E+00
LA2005       21506       21507      0.63835E-09
CA2006       21507           0      0.94876E-15
RA2006       21507           0      0.41938E+09
CA2007       21510           0      0.94876E-15
RA2007       21510           0      0.41938E+09
RA2008       21509       21510      0.53870E-02
VA2008       21508       21509 AC   0.00000E+00
LA2008       21507       21508      0.12767E-08
CA2009       21513           0      0.94876E-15
RA2009       21513           0      0.41938E+09
RA2010       21512       21513      0.53870E-02
VA2010       21511       21512 AC   0.00000E+00
LA2010       21510       21511      0.12767E-08
CA2011       21516           0      0.94876E-15
RA2011       21516           0      0.41938E+09
RA2012       21515       21516      0.53870E-02
VA2012       21514       21515 AC   0.00000E+00
LA2012       21513       21514      0.12767E-08
CA2013       21519           0      0.94876E-15
RA2013       21519           0      0.41938E+09
RA2014       21518       21519      0.53870E-02
VA2014       21517       21518 AC   0.00000E+00
LA2014       21516       21517      0.12767E-08
CA2015       21522           0      0.94876E-15
RA2015       21522           0      0.41938E+09
RA2016       21521       21522      0.53870E-02
VA2016       21520       21521 AC   0.00000E+00
LA2016       21519       21520      0.12767E-08
CA2017       21525           0      0.94876E-15
RA2017       21525           0      0.41938E+09
RA2018       21524       21525      0.53870E-02
VA2018       21523       21524 AC   0.00000E+00
LA2018       21522       21523      0.12767E-08
CA2019       21528           0      0.94876E-15
RA2019       21528           0      0.41938E+09
RA2020       21527       21528      0.53870E-02
VA2020       21526       21527 AC   0.00000E+00
LA2020       21525       21526      0.12767E-08
CA2021       21531           0      0.94876E-15
RA2021       21531           0      0.41938E+09
RA2022       21530       21531      0.53870E-02
VA2022       21529       21530 AC   0.00000E+00
LA2022       21528       21529      0.12767E-08
CA2023       21534           0      0.94876E-15
RA2023       21534           0      0.41938E+09
RA2024       21533       21534      0.53870E-02
VA2024       21532       21533 AC   0.00000E+00
LA2024       21531       21532      0.12767E-08
CA2025       21537           0      0.94876E-15
RA2025       21537           0      0.41938E+09
RA2026       21536       21537      0.53870E-02
VA2026       21535       21536 AC   0.00000E+00
LA2026       21534       21535      0.12767E-08
CA2027       21540           0      0.94876E-15
RA2027       21540           0      0.41938E+09
RA2028       21539       21540      0.53870E-02
VA2028       21538       21539 AC   0.00000E+00
LA2028       21537       21538      0.12767E-08
CA2029       21543           0      0.94876E-15
RA2029       21543           0      0.41938E+09
RA2030       21542       21543      0.53870E-02
VA2030       21541       21542 AC   0.00000E+00
LA2030       21540       21541      0.12767E-08
CA2031       21546           0      0.94876E-15
RA2031       21546           0      0.41938E+09
RA2032       21545       21546      0.53870E-02
VA2032       21544       21545 AC   0.00000E+00
LA2032       21543       21544      0.12767E-08
CA2033       21549           0      0.94876E-15
RA2033       21549           0      0.41938E+09
RA2034       21548       21549      0.53870E-02
VA2034       21547       21548 AC   0.00000E+00
LA2034       21546       21547      0.12767E-08
CA2035       21552           0      0.94876E-15
RA2035       21552           0      0.41938E+09
RA2036       21551       21552      0.53870E-02
VA2036       21550       21551 AC   0.00000E+00
LA2036       21549       21550      0.12767E-08
CA2037       21555           0      0.94876E-15
RA2037       21555           0      0.41938E+09
RA2038       21554       21555      0.53870E-02
VA2038       21553       21554 AC   0.00000E+00
LA2038       21552       21553      0.12767E-08
CA2039       21558           0      0.94876E-15
RA2039       21558           0      0.41938E+09
RA2040       21557       21558      0.53870E-02
VA2040       21556       21557 AC   0.00000E+00
LA2040       21555       21556      0.12767E-08
CA2041       21561           0      0.94876E-15
RA2041       21561           0      0.41938E+09
RA2042       21560       21561      0.53870E-02
VA2042       21559       21560 AC   0.00000E+00
LA2042       21558       21559      0.12767E-08
CA2043       21564           0      0.51451E-14
RA2043       21564           0      0.41938E+09
RA2044       21563       21564      0.53870E-02
VA2044       21562       21563 AC   0.00000E+00
LA2044       21561       21562      0.12767E-08
CA2045       21565           0      0.50868E-14
RA2045       21565           0      0.41938E+09
CA2046       21568           0      0.94876E-15
RA2046       21568           0      0.41938E+09
RA2047       21567       21568      0.53870E-02
VA2047       21566       21567 AC   0.00000E+00
LA2047       21565       21566      0.12767E-08
CA2048       21571           0      0.94876E-15
RA2048       21571           0      0.41938E+09
RA2049       21570       21571      0.53870E-02
VA2049       21569       21570 AC   0.00000E+00
LA2049       21568       21569      0.12767E-08
CA2050       21574           0      0.94876E-15
RA2050       21574           0      0.41938E+09
RA2051       21573       21574      0.53870E-02
VA2051       21572       21573 AC   0.00000E+00
LA2051       21571       21572      0.12767E-08
CA2052       21577           0      0.94876E-15
RA2052       21577           0      0.41938E+09
RA2053       21576       21577      0.53870E-02
VA2053       21575       21576 AC   0.00000E+00
LA2053       21574       21575      0.12767E-08
CA2054       21580           0      0.94876E-15
RA2054       21580           0      0.41938E+09
RA2055       21579       21580      0.53870E-02
VA2055       21578       21579 AC   0.00000E+00
LA2055       21577       21578      0.12767E-08
CA2056       21583           0      0.94876E-15
RA2056       21583           0      0.41938E+09
RA2057       21582       21583      0.53870E-02
VA2057       21581       21582 AC   0.00000E+00
LA2057       21580       21581      0.12767E-08
CA2058       21586           0      0.94876E-15
RA2058       21586           0      0.41938E+09
RA2059       21585       21586      0.53870E-02
VA2059       21584       21585 AC   0.00000E+00
LA2059       21583       21584      0.12767E-08
CA2060       21589           0      0.94876E-15
RA2060       21589           0      0.41938E+09
RA2061       21588       21589      0.53870E-02
VA2061       21587       21588 AC   0.00000E+00
LA2061       21586       21587      0.12767E-08
CA2062       21592           0      0.94876E-15
RA2062       21592           0      0.41938E+09
RA2063       21591       21592      0.53870E-02
VA2063       21590       21591 AC   0.00000E+00
LA2063       21589       21590      0.12767E-08
CA2064       21595           0      0.94876E-15
RA2064       21595           0      0.41938E+09
RA2065       21594       21595      0.53870E-02
VA2065       21593       21594 AC   0.00000E+00
LA2065       21592       21593      0.12767E-08
CA2066       21598           0      0.94876E-15
RA2066       21598           0      0.41938E+09
RA2067       21597       21598      0.53870E-02
VA2067       21596       21597 AC   0.00000E+00
LA2067       21595       21596      0.12767E-08
CA2068       21601           0      0.94876E-15
RA2068       21601           0      0.41938E+09
RA2069       21600       21601      0.53870E-02
VA2069       21599       21600 AC   0.00000E+00
LA2069       21598       21599      0.12767E-08
CA2070       21604           0      0.16377E-14
RA2070       21604           0      0.41938E+09
RA2071       21603       21604      0.53870E-02
VA2071       21602       21603 AC   0.00000E+00
LA2071       21601       21602      0.12767E-08
RA2072           0       21605      0.26935E-02
VA2072       21605       21606 AC   0.00000E+00
LA2072       21606       21607      0.63835E-09
CA2073       21607           0      0.94876E-15
RA2073       21607           0      0.41938E+09
CA2074       21610           0      0.94876E-15
RA2074       21610           0      0.41938E+09
RA2075       21609       21610      0.53870E-02
VA2075       21608       21609 AC   0.00000E+00
LA2075       21607       21608      0.12767E-08
CA2076       21613           0      0.94876E-15
RA2076       21613           0      0.41938E+09
RA2077       21612       21613      0.53870E-02
VA2077       21611       21612 AC   0.00000E+00
LA2077       21610       21611      0.12767E-08
CA2078       21616           0      0.94876E-15
RA2078       21616           0      0.41938E+09
RA2079       21615       21616      0.53870E-02
VA2079       21614       21615 AC   0.00000E+00
LA2079       21613       21614      0.12767E-08
CA2080       21619           0      0.94876E-15
RA2080       21619           0      0.41938E+09
RA2081       21618       21619      0.53870E-02
VA2081       21617       21618 AC   0.00000E+00
LA2081       21616       21617      0.12767E-08
CA2082       21622           0      0.94876E-15
RA2082       21622           0      0.41938E+09
RA2083       21621       21622      0.53870E-02
VA2083       21620       21621 AC   0.00000E+00
LA2083       21619       21620      0.12767E-08
CA2084       21625           0      0.94876E-15
RA2084       21625           0      0.41938E+09
RA2085       21624       21625      0.53870E-02
VA2085       21623       21624 AC   0.00000E+00
LA2085       21622       21623      0.12767E-08
CA2086       21628           0      0.94876E-15
RA2086       21628           0      0.41938E+09
RA2087       21627       21628      0.53870E-02
VA2087       21626       21627 AC   0.00000E+00
LA2087       21625       21626      0.12767E-08
CA2088       21631           0      0.94876E-15
RA2088       21631           0      0.41938E+09
RA2089       21630       21631      0.53870E-02
VA2089       21629       21630 AC   0.00000E+00
LA2089       21628       21629      0.12767E-08
CA2090       21634           0      0.94876E-15
RA2090       21634           0      0.41938E+09
RA2091       21633       21634      0.53870E-02
VA2091       21632       21633 AC   0.00000E+00
LA2091       21631       21632      0.12767E-08
CA2092       21637           0      0.94876E-15
RA2092       21637           0      0.41938E+09
RA2093       21636       21637      0.53870E-02
VA2093       21635       21636 AC   0.00000E+00
LA2093       21634       21635      0.12767E-08
CA2094       21640           0      0.94876E-15
RA2094       21640           0      0.41938E+09
RA2095       21639       21640      0.53870E-02
VA2095       21638       21639 AC   0.00000E+00
LA2095       21637       21638      0.12767E-08
CA2096       21643           0      0.94876E-15
RA2096       21643           0      0.41938E+09
RA2097       21642       21643      0.53870E-02
VA2097       21641       21642 AC   0.00000E+00
LA2097       21640       21641      0.12767E-08
CA2098       21646           0      0.94876E-15
RA2098       21646           0      0.41938E+09
RA2099       21645       21646      0.53870E-02
VA2099       21644       21645 AC   0.00000E+00
LA2099       21643       21644      0.12767E-08
CA2100       21649           0      0.94876E-15
RA2100       21649           0      0.41938E+09
RA2101       21648       21649      0.53870E-02
VA2101       21647       21648 AC   0.00000E+00
LA2101       21646       21647      0.12767E-08
CA2102       21652           0      0.94876E-15
RA2102       21652           0      0.41938E+09
RA2103       21651       21652      0.53870E-02
VA2103       21650       21651 AC   0.00000E+00
LA2103       21649       21650      0.12767E-08
CA2104       21655           0      0.94876E-15
RA2104       21655           0      0.41938E+09
RA2105       21654       21655      0.53870E-02
VA2105       21653       21654 AC   0.00000E+00
LA2105       21652       21653      0.12767E-08
CA2106       21658           0      0.94876E-15
RA2106       21658           0      0.41938E+09
RA2107       21657       21658      0.53870E-02
VA2107       21656       21657 AC   0.00000E+00
LA2107       21655       21656      0.12767E-08
CA2108       21661           0      0.94876E-15
RA2108       21661           0      0.41938E+09
RA2109       21660       21661      0.53870E-02
VA2109       21659       21660 AC   0.00000E+00
LA2109       21658       21659      0.12767E-08
CA2110       21664           0      0.51451E-14
RA2110       21664           0      0.41938E+09
RA2111       21663       21664      0.53870E-02
VA2111       21662       21663 AC   0.00000E+00
LA2111       21661       21662      0.12767E-08
CA2112       21665           0      0.50868E-14
RA2112       21665           0      0.41938E+09
CA2113       21668           0      0.94876E-15
RA2113       21668           0      0.41938E+09
RA2114       21667       21668      0.53870E-02
VA2114       21666       21667 AC   0.00000E+00
LA2114       21665       21666      0.12767E-08
CA2115       21671           0      0.94876E-15
RA2115       21671           0      0.41938E+09
RA2116       21670       21671      0.53870E-02
VA2116       21669       21670 AC   0.00000E+00
LA2116       21668       21669      0.12767E-08
CA2117       21674           0      0.94876E-15
RA2117       21674           0      0.41938E+09
RA2118       21673       21674      0.53870E-02
VA2118       21672       21673 AC   0.00000E+00
LA2118       21671       21672      0.12767E-08
CA2119       21677           0      0.94876E-15
RA2119       21677           0      0.41938E+09
RA2120       21676       21677      0.53870E-02
VA2120       21675       21676 AC   0.00000E+00
LA2120       21674       21675      0.12767E-08
CA2121       21680           0      0.94876E-15
RA2121       21680           0      0.41938E+09
RA2122       21679       21680      0.53870E-02
VA2122       21678       21679 AC   0.00000E+00
LA2122       21677       21678      0.12767E-08
CA2123       21683           0      0.94876E-15
RA2123       21683           0      0.41938E+09
RA2124       21682       21683      0.53870E-02
VA2124       21681       21682 AC   0.00000E+00
LA2124       21680       21681      0.12767E-08
CA2125       21686           0      0.94876E-15
RA2125       21686           0      0.41938E+09
RA2126       21685       21686      0.53870E-02
VA2126       21684       21685 AC   0.00000E+00
LA2126       21683       21684      0.12767E-08
CA2127       21689           0      0.94876E-15
RA2127       21689           0      0.41938E+09
RA2128       21688       21689      0.53870E-02
VA2128       21687       21688 AC   0.00000E+00
LA2128       21686       21687      0.12767E-08
CA2129       21692           0      0.94876E-15
RA2129       21692           0      0.41938E+09
RA2130       21691       21692      0.53870E-02
VA2130       21690       21691 AC   0.00000E+00
LA2130       21689       21690      0.12767E-08
CA2131       21695           0      0.94876E-15
RA2131       21695           0      0.41938E+09
RA2132       21694       21695      0.53870E-02
VA2132       21693       21694 AC   0.00000E+00
LA2132       21692       21693      0.12767E-08
CA2133       21698           0      0.94876E-15
RA2133       21698           0      0.41938E+09
RA2134       21697       21698      0.53870E-02
VA2134       21696       21697 AC   0.00000E+00
LA2134       21695       21696      0.12767E-08
CA2135       21701           0      0.94876E-15
RA2135       21701           0      0.41938E+09
RA2136       21700       21701      0.53870E-02
VA2136       21699       21700 AC   0.00000E+00
LA2136       21698       21699      0.12767E-08
CA2137       21704           0      0.16377E-14
RA2137       21704           0      0.41938E+09
RA2138       21703       21704      0.53870E-02
VA2138       21702       21703 AC   0.00000E+00
LA2138       21701       21702      0.12767E-08
RA2139           0       21705      0.26935E-02
VA2139       21705       21706 AC   0.00000E+00
LA2139       21706       21707      0.63835E-09
CA2140       21707           0      0.94876E-15
RA2140       21707           0      0.41938E+09
CA2141       21710           0      0.94876E-15
RA2141       21710           0      0.41938E+09
RA2142       21709       21710      0.53870E-02
VA2142       21708       21709 AC   0.00000E+00
LA2142       21707       21708      0.12767E-08
CA2143       21713           0      0.94876E-15
RA2143       21713           0      0.41938E+09
RA2144       21712       21713      0.53870E-02
VA2144       21711       21712 AC   0.00000E+00
LA2144       21710       21711      0.12767E-08
CA2145       21716           0      0.94876E-15
RA2145       21716           0      0.41938E+09
RA2146       21715       21716      0.53870E-02
VA2146       21714       21715 AC   0.00000E+00
LA2146       21713       21714      0.12767E-08
CA2147       21719           0      0.94876E-15
RA2147       21719           0      0.41938E+09
RA2148       21718       21719      0.53870E-02
VA2148       21717       21718 AC   0.00000E+00
LA2148       21716       21717      0.12767E-08
CA2149       21722           0      0.94876E-15
RA2149       21722           0      0.41938E+09
RA2150       21721       21722      0.53870E-02
VA2150       21720       21721 AC   0.00000E+00
LA2150       21719       21720      0.12767E-08
CA2151       21725           0      0.94876E-15
RA2151       21725           0      0.41938E+09
RA2152       21724       21725      0.53870E-02
VA2152       21723       21724 AC   0.00000E+00
LA2152       21722       21723      0.12767E-08
CA2153       21728           0      0.94876E-15
RA2153       21728           0      0.41938E+09
RA2154       21727       21728      0.53870E-02
VA2154       21726       21727 AC   0.00000E+00
LA2154       21725       21726      0.12767E-08
CA2155       21731           0      0.94876E-15
RA2155       21731           0      0.41938E+09
RA2156       21730       21731      0.53870E-02
VA2156       21729       21730 AC   0.00000E+00
LA2156       21728       21729      0.12767E-08
CA2157       21734           0      0.94876E-15
RA2157       21734           0      0.41938E+09
RA2158       21733       21734      0.53870E-02
VA2158       21732       21733 AC   0.00000E+00
LA2158       21731       21732      0.12767E-08
CA2159       21737           0      0.94876E-15
RA2159       21737           0      0.41938E+09
RA2160       21736       21737      0.53870E-02
VA2160       21735       21736 AC   0.00000E+00
LA2160       21734       21735      0.12767E-08
CA2161       21740           0      0.94876E-15
RA2161       21740           0      0.41938E+09
RA2162       21739       21740      0.53870E-02
VA2162       21738       21739 AC   0.00000E+00
LA2162       21737       21738      0.12767E-08
CA2163       21743           0      0.94876E-15
RA2163       21743           0      0.41938E+09
RA2164       21742       21743      0.53870E-02
VA2164       21741       21742 AC   0.00000E+00
LA2164       21740       21741      0.12767E-08
CA2165       21746           0      0.94876E-15
RA2165       21746           0      0.41938E+09
RA2166       21745       21746      0.53870E-02
VA2166       21744       21745 AC   0.00000E+00
LA2166       21743       21744      0.12767E-08
CA2167       21749           0      0.94876E-15
RA2167       21749           0      0.41938E+09
RA2168       21748       21749      0.53870E-02
VA2168       21747       21748 AC   0.00000E+00
LA2168       21746       21747      0.12767E-08
CA2169       21752           0      0.94876E-15
RA2169       21752           0      0.41938E+09
RA2170       21751       21752      0.53870E-02
VA2170       21750       21751 AC   0.00000E+00
LA2170       21749       21750      0.12767E-08
CA2171       21755           0      0.94876E-15
RA2171       21755           0      0.41938E+09
RA2172       21754       21755      0.53870E-02
VA2172       21753       21754 AC   0.00000E+00
LA2172       21752       21753      0.12767E-08
CA2173       21758           0      0.94876E-15
RA2173       21758           0      0.41938E+09
RA2174       21757       21758      0.53870E-02
VA2174       21756       21757 AC   0.00000E+00
LA2174       21755       21756      0.12767E-08
CA2175       21761           0      0.94876E-15
RA2175       21761           0      0.41938E+09
RA2176       21760       21761      0.53870E-02
VA2176       21759       21760 AC   0.00000E+00
LA2176       21758       21759      0.12767E-08
CA2177       21764           0      0.51451E-14
RA2177       21764           0      0.41938E+09
RA2178       21763       21764      0.53870E-02
VA2178       21762       21763 AC   0.00000E+00
LA2178       21761       21762      0.12767E-08
CA2179       21765           0      0.50868E-14
RA2179       21765           0      0.41938E+09
CA2180       21768           0      0.94876E-15
RA2180       21768           0      0.41938E+09
RA2181       21767       21768      0.53870E-02
VA2181       21766       21767 AC   0.00000E+00
LA2181       21765       21766      0.12767E-08
CA2182       21771           0      0.94876E-15
RA2182       21771           0      0.41938E+09
RA2183       21770       21771      0.53870E-02
VA2183       21769       21770 AC   0.00000E+00
LA2183       21768       21769      0.12767E-08
CA2184       21774           0      0.94876E-15
RA2184       21774           0      0.41938E+09
RA2185       21773       21774      0.53870E-02
VA2185       21772       21773 AC   0.00000E+00
LA2185       21771       21772      0.12767E-08
CA2186       21777           0      0.94876E-15
RA2186       21777           0      0.41938E+09
RA2187       21776       21777      0.53870E-02
VA2187       21775       21776 AC   0.00000E+00
LA2187       21774       21775      0.12767E-08
CA2188       21780           0      0.94876E-15
RA2188       21780           0      0.41938E+09
RA2189       21779       21780      0.53870E-02
VA2189       21778       21779 AC   0.00000E+00
LA2189       21777       21778      0.12767E-08
CA2190       21783           0      0.94876E-15
RA2190       21783           0      0.41938E+09
RA2191       21782       21783      0.53870E-02
VA2191       21781       21782 AC   0.00000E+00
LA2191       21780       21781      0.12767E-08
CA2192       21786           0      0.94876E-15
RA2192       21786           0      0.41938E+09
RA2193       21785       21786      0.53870E-02
VA2193       21784       21785 AC   0.00000E+00
LA2193       21783       21784      0.12767E-08
CA2194       21789           0      0.94876E-15
RA2194       21789           0      0.41938E+09
RA2195       21788       21789      0.53870E-02
VA2195       21787       21788 AC   0.00000E+00
LA2195       21786       21787      0.12767E-08
CA2196       21792           0      0.94876E-15
RA2196       21792           0      0.41938E+09
RA2197       21791       21792      0.53870E-02
VA2197       21790       21791 AC   0.00000E+00
LA2197       21789       21790      0.12767E-08
CA2198       21795           0      0.94876E-15
RA2198       21795           0      0.41938E+09
RA2199       21794       21795      0.53870E-02
VA2199       21793       21794 AC   0.00000E+00
LA2199       21792       21793      0.12767E-08
CA2200       21798           0      0.94876E-15
RA2200       21798           0      0.41938E+09
RA2201       21797       21798      0.53870E-02
VA2201       21796       21797 AC   0.00000E+00
LA2201       21795       21796      0.12767E-08
CA2202       21801           0      0.94876E-15
RA2202       21801           0      0.41938E+09
RA2203       21800       21801      0.53870E-02
VA2203       21799       21800 AC   0.00000E+00
LA2203       21798       21799      0.12767E-08
CA2204       21804           0      0.16377E-14
RA2204       21804           0      0.41938E+09
RA2205       21803       21804      0.53870E-02
VA2205       21802       21803 AC   0.00000E+00
LA2205       21801       21802      0.12767E-08
RA2206           0       21805      0.26935E-02
VA2206       21805       21806 AC   0.00000E+00
LA2206       21806       21807      0.63835E-09
CA2207       21807           0      0.94876E-15
RA2207       21807           0      0.41938E+09
CA2208       21810           0      0.94876E-15
RA2208       21810           0      0.41938E+09
RA2209       21809       21810      0.53870E-02
VA2209       21808       21809 AC   0.00000E+00
LA2209       21807       21808      0.12767E-08
CA2210       21813           0      0.94876E-15
RA2210       21813           0      0.41938E+09
RA2211       21812       21813      0.53870E-02
VA2211       21811       21812 AC   0.00000E+00
LA2211       21810       21811      0.12767E-08
CA2212       21816           0      0.94876E-15
RA2212       21816           0      0.41938E+09
RA2213       21815       21816      0.53870E-02
VA2213       21814       21815 AC   0.00000E+00
LA2213       21813       21814      0.12767E-08
CA2214       21819           0      0.94876E-15
RA2214       21819           0      0.41938E+09
RA2215       21818       21819      0.53870E-02
VA2215       21817       21818 AC   0.00000E+00
LA2215       21816       21817      0.12767E-08
CA2216       21822           0      0.94876E-15
RA2216       21822           0      0.41938E+09
RA2217       21821       21822      0.53870E-02
VA2217       21820       21821 AC   0.00000E+00
LA2217       21819       21820      0.12767E-08
CA2218       21825           0      0.94876E-15
RA2218       21825           0      0.41938E+09
RA2219       21824       21825      0.53870E-02
VA2219       21823       21824 AC   0.00000E+00
LA2219       21822       21823      0.12767E-08
CA2220       21828           0      0.94876E-15
RA2220       21828           0      0.41938E+09
RA2221       21827       21828      0.53870E-02
VA2221       21826       21827 AC   0.00000E+00
LA2221       21825       21826      0.12767E-08
CA2222       21831           0      0.94876E-15
RA2222       21831           0      0.41938E+09
RA2223       21830       21831      0.53870E-02
VA2223       21829       21830 AC   0.00000E+00
LA2223       21828       21829      0.12767E-08
CA2224       21834           0      0.94876E-15
RA2224       21834           0      0.41938E+09
RA2225       21833       21834      0.53870E-02
VA2225       21832       21833 AC   0.00000E+00
LA2225       21831       21832      0.12767E-08
CA2226       21837           0      0.94876E-15
RA2226       21837           0      0.41938E+09
RA2227       21836       21837      0.53870E-02
VA2227       21835       21836 AC   0.00000E+00
LA2227       21834       21835      0.12767E-08
CA2228       21840           0      0.94876E-15
RA2228       21840           0      0.41938E+09
RA2229       21839       21840      0.53870E-02
VA2229       21838       21839 AC   0.00000E+00
LA2229       21837       21838      0.12767E-08
CA2230       21843           0      0.94876E-15
RA2230       21843           0      0.41938E+09
RA2231       21842       21843      0.53870E-02
VA2231       21841       21842 AC   0.00000E+00
LA2231       21840       21841      0.12767E-08
CA2232       21846           0      0.94876E-15
RA2232       21846           0      0.41938E+09
RA2233       21845       21846      0.53870E-02
VA2233       21844       21845 AC   0.00000E+00
LA2233       21843       21844      0.12767E-08
CA2234       21849           0      0.94876E-15
RA2234       21849           0      0.41938E+09
RA2235       21848       21849      0.53870E-02
VA2235       21847       21848 AC   0.00000E+00
LA2235       21846       21847      0.12767E-08
CA2236       21852           0      0.94876E-15
RA2236       21852           0      0.41938E+09
RA2237       21851       21852      0.53870E-02
VA2237       21850       21851 AC   0.00000E+00
LA2237       21849       21850      0.12767E-08
CA2238       21855           0      0.94876E-15
RA2238       21855           0      0.41938E+09
RA2239       21854       21855      0.53870E-02
VA2239       21853       21854 AC   0.00000E+00
LA2239       21852       21853      0.12767E-08
CA2240       21858           0      0.94876E-15
RA2240       21858           0      0.41938E+09
RA2241       21857       21858      0.53870E-02
VA2241       21856       21857 AC   0.00000E+00
LA2241       21855       21856      0.12767E-08
CA2242       21861           0      0.94876E-15
RA2242       21861           0      0.41938E+09
RA2243       21860       21861      0.53870E-02
VA2243       21859       21860 AC   0.00000E+00
LA2243       21858       21859      0.12767E-08
CA2244       21864           0      0.51451E-14
RA2244       21864           0      0.41938E+09
RA2245       21863       21864      0.53870E-02
VA2245       21862       21863 AC   0.00000E+00
LA2245       21861       21862      0.12767E-08
CA2246       21865           0      0.50977E-14
RA2246       21865           0      0.41938E+09
CA2247       21868           0      0.51086E-14
RA2247       21868           0      0.41938E+09
RA2248       21867       21868      0.53870E-02
VA2248       21866       21867 AC   0.00000E+00
LA2248       21865       21866      0.12934E-09
CA2249       21871           0      0.51086E-14
RA2249       21871           0      0.41938E+09
RA2250       21870       21871      0.53870E-02
VA2250       21869       21870 AC   0.00000E+00
LA2250       21868       21869      0.12934E-09
CA2251       21874           0      0.51086E-14
RA2251       21874           0      0.41938E+09
RA2252       21873       21874      0.53870E-02
VA2252       21872       21873 AC   0.00000E+00
LA2252       21871       21872      0.12934E-09
CA2253       21877           0      0.51086E-14
RA2253       21877           0      0.41938E+09
RA2254       21876       21877      0.53870E-02
VA2254       21875       21876 AC   0.00000E+00
LA2254       21874       21875      0.12934E-09
CA2255       21880           0      0.51086E-14
RA2255       21880           0      0.41938E+09
RA2256       21879       21880      0.53870E-02
VA2256       21878       21879 AC   0.00000E+00
LA2256       21877       21878      0.12934E-09
CA2257       21883           0      0.51086E-14
RA2257       21883           0      0.41938E+09
RA2258       21882       21883      0.53870E-02
VA2258       21881       21882 AC   0.00000E+00
LA2258       21880       21881      0.12934E-09
CA2259       21886           0      0.51086E-14
RA2259       21886           0      0.41938E+09
RA2260       21885       21886      0.53870E-02
VA2260       21884       21885 AC   0.00000E+00
LA2260       21883       21884      0.12934E-09
CA2261       21889           0      0.51086E-14
RA2261       21889           0      0.41938E+09
RA2262       21888       21889      0.53870E-02
VA2262       21887       21888 AC   0.00000E+00
LA2262       21886       21887      0.12934E-09
CA2263       21892           0      0.51086E-14
RA2263       21892           0      0.41938E+09
RA2264       21891       21892      0.53870E-02
VA2264       21890       21891 AC   0.00000E+00
LA2264       21889       21890      0.12934E-09
CA2265       21895           0      0.51086E-14
RA2265       21895           0      0.41938E+09
RA2266       21894       21895      0.53870E-02
VA2266       21893       21894 AC   0.00000E+00
LA2266       21892       21893      0.12934E-09
CA2267       21898           0      0.51086E-14
RA2267       21898           0      0.41938E+09
RA2268       21897       21898      0.53870E-02
VA2268       21896       21897 AC   0.00000E+00
LA2268       21895       21896      0.12934E-09
CA2269       21901           0      0.51086E-14
RA2269       21901           0      0.41938E+09
RA2270       21900       21901      0.53870E-02
VA2270       21899       21900 AC   0.00000E+00
LA2270       21898       21899      0.12934E-09
CA2271       21904           0      0.33732E-14
RA2271       21904           0      0.41938E+09
RA2272       21903       21904      0.53870E-02
VA2272       21902       21903 AC   0.00000E+00
LA2272       21901       21902      0.12934E-09
RA2273           0       21905      0.26935E-02
VA2273       21905       21906 AC   0.00000E+00
LA2273       21906       21907      0.63835E-09
CA2274       21907           0      0.94876E-15
RA2274       21907           0      0.41938E+09
CA2275       21910           0      0.94876E-15
RA2275       21910           0      0.41938E+09
RA2276       21909       21910      0.53870E-02
VA2276       21908       21909 AC   0.00000E+00
LA2276       21907       21908      0.12767E-08
CA2277       21913           0      0.94876E-15
RA2277       21913           0      0.41938E+09
RA2278       21912       21913      0.53870E-02
VA2278       21911       21912 AC   0.00000E+00
LA2278       21910       21911      0.12767E-08
CA2279       21916           0      0.94876E-15
RA2279       21916           0      0.41938E+09
RA2280       21915       21916      0.53870E-02
VA2280       21914       21915 AC   0.00000E+00
LA2280       21913       21914      0.12767E-08
CA2281       21919           0      0.94876E-15
RA2281       21919           0      0.41938E+09
RA2282       21918       21919      0.53870E-02
VA2282       21917       21918 AC   0.00000E+00
LA2282       21916       21917      0.12767E-08
CA2283       21922           0      0.94876E-15
RA2283       21922           0      0.41938E+09
RA2284       21921       21922      0.53870E-02
VA2284       21920       21921 AC   0.00000E+00
LA2284       21919       21920      0.12767E-08
CA2285       21925           0      0.94876E-15
RA2285       21925           0      0.41938E+09
RA2286       21924       21925      0.53870E-02
VA2286       21923       21924 AC   0.00000E+00
LA2286       21922       21923      0.12767E-08
CA2287       21928           0      0.94876E-15
RA2287       21928           0      0.41938E+09
RA2288       21927       21928      0.53870E-02
VA2288       21926       21927 AC   0.00000E+00
LA2288       21925       21926      0.12767E-08
CA2289       21931           0      0.94876E-15
RA2289       21931           0      0.41938E+09
RA2290       21930       21931      0.53870E-02
VA2290       21929       21930 AC   0.00000E+00
LA2290       21928       21929      0.12767E-08
CA2291       21934           0      0.94876E-15
RA2291       21934           0      0.41938E+09
RA2292       21933       21934      0.53870E-02
VA2292       21932       21933 AC   0.00000E+00
LA2292       21931       21932      0.12767E-08
CA2293       21937           0      0.94876E-15
RA2293       21937           0      0.41938E+09
RA2294       21936       21937      0.53870E-02
VA2294       21935       21936 AC   0.00000E+00
LA2294       21934       21935      0.12767E-08
CA2295       21940           0      0.94876E-15
RA2295       21940           0      0.41938E+09
RA2296       21939       21940      0.53870E-02
VA2296       21938       21939 AC   0.00000E+00
LA2296       21937       21938      0.12767E-08
CA2297       21943           0      0.94876E-15
RA2297       21943           0      0.41938E+09
RA2298       21942       21943      0.53870E-02
VA2298       21941       21942 AC   0.00000E+00
LA2298       21940       21941      0.12767E-08
CA2299       21946           0      0.94876E-15
RA2299       21946           0      0.41938E+09
RA2300       21945       21946      0.53870E-02
VA2300       21944       21945 AC   0.00000E+00
LA2300       21943       21944      0.12767E-08
CA2301       21949           0      0.94876E-15
RA2301       21949           0      0.41938E+09
RA2302       21948       21949      0.53870E-02
VA2302       21947       21948 AC   0.00000E+00
LA2302       21946       21947      0.12767E-08
CA2303       21952           0      0.94876E-15
RA2303       21952           0      0.41938E+09
RA2304       21951       21952      0.53870E-02
VA2304       21950       21951 AC   0.00000E+00
LA2304       21949       21950      0.12767E-08
CA2305       21955           0      0.94876E-15
RA2305       21955           0      0.41938E+09
RA2306       21954       21955      0.53870E-02
VA2306       21953       21954 AC   0.00000E+00
LA2306       21952       21953      0.12767E-08
CA2307       21958           0      0.94876E-15
RA2307       21958           0      0.41938E+09
RA2308       21957       21958      0.53870E-02
VA2308       21956       21957 AC   0.00000E+00
LA2308       21955       21956      0.12767E-08
CA2309       21961           0      0.94876E-15
RA2309       21961           0      0.41938E+09
RA2310       21960       21961      0.53870E-02
VA2310       21959       21960 AC   0.00000E+00
LA2310       21958       21959      0.12767E-08
CA2311       21964           0      0.51451E-14
RA2311       21964           0      0.41938E+09
RA2312       21963       21964      0.53870E-02
VA2312       21962       21963 AC   0.00000E+00
LA2312       21961       21962      0.12767E-08
RA2313           0       21965      0.26935E-02
VA2313       21965       21966 AC   0.00000E+00
LA2313       21966       21967      0.63469E-10
CA2314       21967           0      0.51279E-14
RA2314       21967           0      0.41938E+09
CA2315       21970           0      0.51279E-14
RA2315       21970           0      0.41938E+09
RA2316       21969       21970      0.53870E-02
VA2316       21968       21969 AC   0.00000E+00
LA2316       21967       21968      0.12694E-09
CA2317       21973           0      0.51279E-14
RA2317       21973           0      0.41938E+09
RA2318       21972       21973      0.53870E-02
VA2318       21971       21972 AC   0.00000E+00
LA2318       21970       21971      0.12694E-09
CA2319       21976           0      0.51279E-14
RA2319       21976           0      0.41938E+09
RA2320       21975       21976      0.53870E-02
VA2320       21974       21975 AC   0.00000E+00
LA2320       21973       21974      0.12694E-09
CA2321       21979           0      0.51279E-14
RA2321       21979           0      0.41938E+09
RA2322       21978       21979      0.53870E-02
VA2322       21977       21978 AC   0.00000E+00
LA2322       21976       21977      0.12694E-09
CA2323       21982           0      0.51279E-14
RA2323       21982           0      0.41938E+09
RA2324       21981       21982      0.53870E-02
VA2324       21980       21981 AC   0.00000E+00
LA2324       21979       21980      0.12694E-09
CA2325       21985           0      0.51279E-14
RA2325       21985           0      0.41938E+09
RA2326       21984       21985      0.53870E-02
VA2326       21983       21984 AC   0.00000E+00
LA2326       21982       21983      0.12694E-09
CA2327       21988           0      0.51279E-14
RA2327       21988           0      0.41938E+09
RA2328       21987       21988      0.53870E-02
VA2328       21986       21987 AC   0.00000E+00
LA2328       21985       21986      0.12694E-09
CA2329       21991           0      0.51279E-14
RA2329       21991           0      0.41938E+09
RA2330       21990       21991      0.53870E-02
VA2330       21989       21990 AC   0.00000E+00
LA2330       21988       21989      0.12694E-09
CA2331       21994           0      0.94876E-15
RA2331       21994           0      0.41938E+09
RA2332       21993       21994      0.53870E-02
VA2332       21992       21993 AC   0.00000E+00
LA2332       21991       21992      0.70182E-09
CA2333       21997           0      0.94876E-15
RA2333       21997           0      0.41938E+09
RA2334       21996       21997      0.53870E-02
VA2334       21995       21996 AC   0.00000E+00
LA2334       21994       21995      0.12767E-08
CA2335       22000           0      0.94876E-15
RA2335       22000           0      0.41938E+09
RA2336       21999       22000      0.53870E-02
VA2336       21998       21999 AC   0.00000E+00
LA2336       21997       21998      0.12767E-08
CA2337       22003           0      0.94876E-15
RA2337       22003           0      0.41938E+09
RA2338       22002       22003      0.53870E-02
VA2338       22001       22002 AC   0.00000E+00
LA2338       22000       22001      0.12767E-08
CA2339       22006           0      0.94876E-15
RA2339       22006           0      0.41938E+09
RA2340       22005       22006      0.53870E-02
VA2340       22004       22005 AC   0.00000E+00
LA2340       22003       22004      0.12767E-08
CA2341       22009           0      0.94876E-15
RA2341       22009           0      0.41938E+09
RA2342       22008       22009      0.53870E-02
VA2342       22007       22008 AC   0.00000E+00
LA2342       22006       22007      0.12767E-08
CA2343       22012           0      0.94876E-15
RA2343       22012           0      0.41938E+09
RA2344       22011       22012      0.53870E-02
VA2344       22010       22011 AC   0.00000E+00
LA2344       22009       22010      0.12767E-08
CA2345       22015           0      0.94876E-15
RA2345       22015           0      0.41938E+09
RA2346       22014       22015      0.53870E-02
VA2346       22013       22014 AC   0.00000E+00
LA2346       22012       22013      0.12767E-08
CA2347       22018           0      0.94876E-15
RA2347       22018           0      0.41938E+09
RA2348       22017       22018      0.53870E-02
VA2348       22016       22017 AC   0.00000E+00
LA2348       22015       22016      0.12767E-08
CA2349       22021           0      0.94876E-15
RA2349       22021           0      0.41938E+09
RA2350       22020       22021      0.53870E-02
VA2350       22019       22020 AC   0.00000E+00
LA2350       22018       22019      0.12767E-08
CA2351       22024           0      0.51451E-14
RA2351       22024           0      0.41938E+09
RA2352       22023       22024      0.53870E-02
VA2352       22022       22023 AC   0.00000E+00
LA2352       22021       22022      0.12767E-08
CA2353       22025           0      0.50472E-14
RA2353       22025           0      0.41938E+09
CA2354       22028           0      0.94876E-15
RA2354       22028           0      0.41938E+09
RA2355       22027       22028      0.53870E-02
VA2355       22026       22027 AC   0.00000E+00
LA2355       22025       22026      0.12767E-08
CA2356       22031           0      0.94876E-15
RA2356       22031           0      0.41938E+09
RA2357       22030       22031      0.53870E-02
VA2357       22029       22030 AC   0.00000E+00
LA2357       22028       22029      0.12767E-08
CA2358       22034           0      0.94876E-15
RA2358       22034           0      0.41938E+09
RA2359       22033       22034      0.53870E-02
VA2359       22032       22033 AC   0.00000E+00
LA2359       22031       22032      0.12767E-08
CA2360       22037           0      0.94876E-15
RA2360       22037           0      0.41938E+09
RA2361       22036       22037      0.53870E-02
VA2361       22035       22036 AC   0.00000E+00
LA2361       22034       22035      0.12767E-08
CA2362       22040           0      0.94876E-15
RA2362       22040           0      0.41938E+09
RA2363       22039       22040      0.53870E-02
VA2363       22038       22039 AC   0.00000E+00
LA2363       22037       22038      0.12767E-08
CA2364       22043           0      0.94876E-15
RA2364       22043           0      0.41938E+09
RA2365       22042       22043      0.53870E-02
VA2365       22041       22042 AC   0.00000E+00
LA2365       22040       22041      0.12767E-08
CA2366       22046           0      0.94876E-15
RA2366       22046           0      0.41938E+09
RA2367       22045       22046      0.53870E-02
VA2367       22044       22045 AC   0.00000E+00
LA2367       22043       22044      0.12767E-08
CA2368       22049           0      0.94876E-15
RA2368       22049           0      0.41938E+09
RA2369       22048       22049      0.53870E-02
VA2369       22047       22048 AC   0.00000E+00
LA2369       22046       22047      0.12767E-08
CA2370       22052           0      0.94876E-15
RA2370       22052           0      0.41938E+09
RA2371       22051       22052      0.53870E-02
VA2371       22050       22051 AC   0.00000E+00
LA2371       22049       22050      0.12767E-08
CA2372       22055           0      0.50472E-14
RA2372       22055           0      0.41938E+09
RA2373       22054       22055      0.53870E-02
VA2373       22053       22054 AC   0.00000E+00
LA2373       22052       22053      0.12767E-08
CA2374       22056           0      0.50472E-14
RA2374       22056           0      0.41938E+09
CA2375       22059           0      0.94876E-15
RA2375       22059           0      0.41938E+09
RA2376       22058       22059      0.53870E-02
VA2376       22057       22058 AC   0.00000E+00
LA2376       22056       22057      0.12767E-08
CA2377       22062           0      0.94876E-15
RA2377       22062           0      0.41938E+09
RA2378       22061       22062      0.53870E-02
VA2378       22060       22061 AC   0.00000E+00
LA2378       22059       22060      0.12767E-08
CA2379       22065           0      0.94876E-15
RA2379       22065           0      0.41938E+09
RA2380       22064       22065      0.53870E-02
VA2380       22063       22064 AC   0.00000E+00
LA2380       22062       22063      0.12767E-08
CA2381       22068           0      0.94876E-15
RA2381       22068           0      0.41938E+09
RA2382       22067       22068      0.53870E-02
VA2382       22066       22067 AC   0.00000E+00
LA2382       22065       22066      0.12767E-08
CA2383       22071           0      0.94876E-15
RA2383       22071           0      0.41938E+09
RA2384       22070       22071      0.53870E-02
VA2384       22069       22070 AC   0.00000E+00
LA2384       22068       22069      0.12767E-08
CA2385       22074           0      0.94876E-15
RA2385       22074           0      0.41938E+09
RA2386       22073       22074      0.53870E-02
VA2386       22072       22073 AC   0.00000E+00
LA2386       22071       22072      0.12767E-08
CA2387       22077           0      0.94876E-15
RA2387       22077           0      0.41938E+09
RA2388       22076       22077      0.53870E-02
VA2388       22075       22076 AC   0.00000E+00
LA2388       22074       22075      0.12767E-08
CA2389       22080           0      0.94876E-15
RA2389       22080           0      0.41938E+09
RA2390       22079       22080      0.53870E-02
VA2390       22078       22079 AC   0.00000E+00
LA2390       22077       22078      0.12767E-08
CA2391       22083           0      0.94876E-15
RA2391       22083           0      0.41938E+09
RA2392       22082       22083      0.53870E-02
VA2392       22081       22082 AC   0.00000E+00
LA2392       22080       22081      0.12767E-08
CA2393       22086           0      0.50472E-14
RA2393       22086           0      0.41938E+09
RA2394       22085       22086      0.53870E-02
VA2394       22084       22085 AC   0.00000E+00
LA2394       22083       22084      0.12767E-08
CA2395       22087           0      0.50472E-14
RA2395       22087           0      0.41938E+09
CA2396       22090           0      0.94876E-15
RA2396       22090           0      0.41938E+09
RA2397       22089       22090      0.53870E-02
VA2397       22088       22089 AC   0.00000E+00
LA2397       22087       22088      0.12767E-08
CA2398       22093           0      0.94876E-15
RA2398       22093           0      0.41938E+09
RA2399       22092       22093      0.53870E-02
VA2399       22091       22092 AC   0.00000E+00
LA2399       22090       22091      0.12767E-08
CA2400       22096           0      0.94876E-15
RA2400       22096           0      0.41938E+09
RA2401       22095       22096      0.53870E-02
VA2401       22094       22095 AC   0.00000E+00
LA2401       22093       22094      0.12767E-08
CA2402       22099           0      0.94876E-15
RA2402       22099           0      0.41938E+09
RA2403       22098       22099      0.53870E-02
VA2403       22097       22098 AC   0.00000E+00
LA2403       22096       22097      0.12767E-08
CA2404       22102           0      0.94876E-15
RA2404       22102           0      0.41938E+09
RA2405       22101       22102      0.53870E-02
VA2405       22100       22101 AC   0.00000E+00
LA2405       22099       22100      0.12767E-08
CA2406       22105           0      0.94876E-15
RA2406       22105           0      0.41938E+09
RA2407       22104       22105      0.53870E-02
VA2407       22103       22104 AC   0.00000E+00
LA2407       22102       22103      0.12767E-08
CA2408       22108           0      0.94876E-15
RA2408       22108           0      0.41938E+09
RA2409       22107       22108      0.53870E-02
VA2409       22106       22107 AC   0.00000E+00
LA2409       22105       22106      0.12767E-08
CA2410       22111           0      0.94876E-15
RA2410       22111           0      0.41938E+09
RA2411       22110       22111      0.53870E-02
VA2411       22109       22110 AC   0.00000E+00
LA2411       22108       22109      0.12767E-08
CA2412       22114           0      0.94876E-15
RA2412       22114           0      0.41938E+09
RA2413       22113       22114      0.53870E-02
VA2413       22112       22113 AC   0.00000E+00
LA2413       22111       22112      0.12767E-08
CA2414       22117           0      0.50472E-14
RA2414       22117           0      0.41938E+09
RA2415       22116       22117      0.53870E-02
VA2415       22115       22116 AC   0.00000E+00
LA2415       22114       22115      0.12767E-08
CA2416       22118           0      0.33853E-14
RA2416       22118           0      0.41938E+09
CA2417       22121           0      0.52141E-14
RA2417       22121           0      0.41938E+09
RA2418       22120       22121      0.53870E-02
VA2418       22119       22120 AC   0.00000E+00
LA2418       22118       22119      0.11642E-09
CA2419       22124           0      0.52141E-14
RA2419       22124           0      0.41938E+09
RA2420       22123       22124      0.53870E-02
VA2420       22122       22123 AC   0.00000E+00
LA2420       22121       22122      0.11642E-09
CA2421       22127           0      0.52141E-14
RA2421       22127           0      0.41938E+09
RA2422       22126       22127      0.53870E-02
VA2422       22125       22126 AC   0.00000E+00
LA2422       22124       22125      0.11642E-09
CA2423       22130           0      0.52141E-14
RA2423       22130           0      0.41938E+09
RA2424       22129       22130      0.53870E-02
VA2424       22128       22129 AC   0.00000E+00
LA2424       22127       22128      0.11642E-09
CA2425       22133           0      0.52141E-14
RA2425       22133           0      0.41938E+09
RA2426       22132       22133      0.53870E-02
VA2426       22131       22132 AC   0.00000E+00
LA2426       22130       22131      0.11642E-09
CA2427       22136           0      0.50894E-14
RA2427       22136           0      0.41938E+09
RA2428       22135       22136      0.53870E-02
VA2428       22134       22135 AC   0.00000E+00
LA2428       22133       22134      0.11642E-09
CA2429       22137           0      0.50472E-14
RA2429       22137           0      0.41938E+09
CA2430       22140           0      0.94876E-15
RA2430       22140           0      0.41938E+09
RA2431       22139       22140      0.53870E-02
VA2431       22138       22139 AC   0.00000E+00
LA2431       22137       22138      0.12767E-08
CA2432       22143           0      0.94876E-15
RA2432       22143           0      0.41938E+09
RA2433       22142       22143      0.53870E-02
VA2433       22141       22142 AC   0.00000E+00
LA2433       22140       22141      0.12767E-08
CA2434       22146           0      0.94876E-15
RA2434       22146           0      0.41938E+09
RA2435       22145       22146      0.53870E-02
VA2435       22144       22145 AC   0.00000E+00
LA2435       22143       22144      0.12767E-08
CA2436       22149           0      0.94876E-15
RA2436       22149           0      0.41938E+09
RA2437       22148       22149      0.53870E-02
VA2437       22147       22148 AC   0.00000E+00
LA2437       22146       22147      0.12767E-08
CA2438       22152           0      0.94876E-15
RA2438       22152           0      0.41938E+09
RA2439       22151       22152      0.53870E-02
VA2439       22150       22151 AC   0.00000E+00
LA2439       22149       22150      0.12767E-08
CA2440       22155           0      0.94876E-15
RA2440       22155           0      0.41938E+09
RA2441       22154       22155      0.53870E-02
VA2441       22153       22154 AC   0.00000E+00
LA2441       22152       22153      0.12767E-08
CA2442       22158           0      0.94876E-15
RA2442       22158           0      0.41938E+09
RA2443       22157       22158      0.53870E-02
VA2443       22156       22157 AC   0.00000E+00
LA2443       22155       22156      0.12767E-08
CA2444       22161           0      0.94876E-15
RA2444       22161           0      0.41938E+09
RA2445       22160       22161      0.53870E-02
VA2445       22159       22160 AC   0.00000E+00
LA2445       22158       22159      0.12767E-08
CA2446       22164           0      0.94876E-15
RA2446       22164           0      0.41938E+09
RA2447       22163       22164      0.53870E-02
VA2447       22162       22163 AC   0.00000E+00
LA2447       22161       22162      0.12767E-08
CA2448       22167           0      0.50472E-14
RA2448       22167           0      0.41938E+09
RA2449       22166       22167      0.53870E-02
VA2449       22165       22166 AC   0.00000E+00
LA2449       22164       22165      0.12767E-08
CA2450       22168           0      0.15566E-14
RA2450       22168           0      0.41938E+09
CA2451       22171           0      0.94876E-15
RA2451       22171           0      0.41938E+09
RA2452       22170       22171      0.53870E-02
VA2452       22169       22170 AC   0.00000E+00
LA2452       22168       22169      0.12767E-08
CA2453       22174           0      0.94876E-15
RA2453       22174           0      0.41938E+09
RA2454       22173       22174      0.53870E-02
VA2454       22172       22173 AC   0.00000E+00
LA2454       22171       22172      0.12767E-08
CA2455       22177           0      0.94876E-15
RA2455       22177           0      0.41938E+09
RA2456       22176       22177      0.53870E-02
VA2456       22175       22176 AC   0.00000E+00
LA2456       22174       22175      0.12767E-08
CA2457       22180           0      0.94876E-15
RA2457       22180           0      0.41938E+09
RA2458       22179       22180      0.53870E-02
VA2458       22178       22179 AC   0.00000E+00
LA2458       22177       22178      0.12767E-08
CA2459       22183           0      0.94876E-15
RA2459       22183           0      0.41938E+09
RA2460       22182       22183      0.53870E-02
VA2460       22181       22182 AC   0.00000E+00
LA2460       22180       22181      0.12767E-08
CA2461       22186           0      0.49647E-14
RA2461       22186           0      0.41938E+09
RA2462       22185       22186      0.53870E-02
VA2462       22184       22185 AC   0.00000E+00
LA2462       22183       22184      0.12767E-08
CA2463       22187           0      0.50472E-14
RA2463       22187           0      0.41938E+09
CA2464       22190           0      0.94876E-15
RA2464       22190           0      0.41938E+09
RA2465       22189       22190      0.53870E-02
VA2465       22188       22189 AC   0.00000E+00
LA2465       22187       22188      0.12767E-08
CA2466       22193           0      0.94876E-15
RA2466       22193           0      0.41938E+09
RA2467       22192       22193      0.53870E-02
VA2467       22191       22192 AC   0.00000E+00
LA2467       22190       22191      0.12767E-08
CA2468       22196           0      0.94876E-15
RA2468       22196           0      0.41938E+09
RA2469       22195       22196      0.53870E-02
VA2469       22194       22195 AC   0.00000E+00
LA2469       22193       22194      0.12767E-08
CA2470       22199           0      0.94876E-15
RA2470       22199           0      0.41938E+09
RA2471       22198       22199      0.53870E-02
VA2471       22197       22198 AC   0.00000E+00
LA2471       22196       22197      0.12767E-08
CA2472       22202           0      0.94876E-15
RA2472       22202           0      0.41938E+09
RA2473       22201       22202      0.53870E-02
VA2473       22200       22201 AC   0.00000E+00
LA2473       22199       22200      0.12767E-08
CA2474       22205           0      0.94876E-15
RA2474       22205           0      0.41938E+09
RA2475       22204       22205      0.53870E-02
VA2475       22203       22204 AC   0.00000E+00
LA2475       22202       22203      0.12767E-08
CA2476       22208           0      0.94876E-15
RA2476       22208           0      0.41938E+09
RA2477       22207       22208      0.53870E-02
VA2477       22206       22207 AC   0.00000E+00
LA2477       22205       22206      0.12767E-08
CA2478       22211           0      0.94876E-15
RA2478       22211           0      0.41938E+09
RA2479       22210       22211      0.53870E-02
VA2479       22209       22210 AC   0.00000E+00
LA2479       22208       22209      0.12767E-08
CA2480       22214           0      0.94876E-15
RA2480       22214           0      0.41938E+09
RA2481       22213       22214      0.53870E-02
VA2481       22212       22213 AC   0.00000E+00
LA2481       22211       22212      0.12767E-08
CA2482       22217           0      0.50472E-14
RA2482       22217           0      0.41938E+09
RA2483       22216       22217      0.53870E-02
VA2483       22215       22216 AC   0.00000E+00
LA2483       22214       22215      0.12767E-08
CA2484       22218           0      0.15566E-14
RA2484       22218           0      0.41938E+09
CA2485       22221           0      0.94876E-15
RA2485       22221           0      0.41938E+09
RA2486       22220       22221      0.53870E-02
VA2486       22219       22220 AC   0.00000E+00
LA2486       22218       22219      0.12767E-08
CA2487       22224           0      0.94876E-15
RA2487       22224           0      0.41938E+09
RA2488       22223       22224      0.53870E-02
VA2488       22222       22223 AC   0.00000E+00
LA2488       22221       22222      0.12767E-08
CA2489       22227           0      0.94876E-15
RA2489       22227           0      0.41938E+09
RA2490       22226       22227      0.53870E-02
VA2490       22225       22226 AC   0.00000E+00
LA2490       22224       22225      0.12767E-08
CA2491       22230           0      0.94876E-15
RA2491       22230           0      0.41938E+09
RA2492       22229       22230      0.53870E-02
VA2492       22228       22229 AC   0.00000E+00
LA2492       22227       22228      0.12767E-08
CA2493       22233           0      0.94876E-15
RA2493       22233           0      0.41938E+09
RA2494       22232       22233      0.53870E-02
VA2494       22231       22232 AC   0.00000E+00
LA2494       22230       22231      0.12767E-08
CA2495       22236           0      0.49647E-14
RA2495       22236           0      0.41938E+09
RA2496       22235       22236      0.53870E-02
VA2496       22234       22235 AC   0.00000E+00
LA2496       22233       22234      0.12767E-08
CA2497       22237           0      0.50472E-14
RA2497       22237           0      0.41938E+09
CA2498       22240           0      0.94876E-15
RA2498       22240           0      0.41938E+09
RA2499       22239       22240      0.53870E-02
VA2499       22238       22239 AC   0.00000E+00
LA2499       22237       22238      0.12767E-08
CA2500       22243           0      0.94876E-15
RA2500       22243           0      0.41938E+09
RA2501       22242       22243      0.53870E-02
VA2501       22241       22242 AC   0.00000E+00
LA2501       22240       22241      0.12767E-08
CA2502       22246           0      0.94876E-15
RA2502       22246           0      0.41938E+09
RA2503       22245       22246      0.53870E-02
VA2503       22244       22245 AC   0.00000E+00
LA2503       22243       22244      0.12767E-08
CA2504       22249           0      0.94876E-15
RA2504       22249           0      0.41938E+09
RA2505       22248       22249      0.53870E-02
VA2505       22247       22248 AC   0.00000E+00
LA2505       22246       22247      0.12767E-08
CA2506       22252           0      0.94876E-15
RA2506       22252           0      0.41938E+09
RA2507       22251       22252      0.53870E-02
VA2507       22250       22251 AC   0.00000E+00
LA2507       22249       22250      0.12767E-08
CA2508       22255           0      0.94876E-15
RA2508       22255           0      0.41938E+09
RA2509       22254       22255      0.53870E-02
VA2509       22253       22254 AC   0.00000E+00
LA2509       22252       22253      0.12767E-08
CA2510       22258           0      0.94876E-15
RA2510       22258           0      0.41938E+09
RA2511       22257       22258      0.53870E-02
VA2511       22256       22257 AC   0.00000E+00
LA2511       22255       22256      0.12767E-08
CA2512       22261           0      0.94876E-15
RA2512       22261           0      0.41938E+09
RA2513       22260       22261      0.53870E-02
VA2513       22259       22260 AC   0.00000E+00
LA2513       22258       22259      0.12767E-08
CA2514       22264           0      0.94876E-15
RA2514       22264           0      0.41938E+09
RA2515       22263       22264      0.53870E-02
VA2515       22262       22263 AC   0.00000E+00
LA2515       22261       22262      0.12767E-08
CA2516       22267           0      0.50472E-14
RA2516       22267           0      0.41938E+09
RA2517       22266       22267      0.53870E-02
VA2517       22265       22266 AC   0.00000E+00
LA2517       22264       22265      0.12767E-08
CA2518       22268           0      0.15566E-14
RA2518       22268           0      0.41938E+09
CA2519       22271           0      0.94876E-15
RA2519       22271           0      0.41938E+09
RA2520       22270       22271      0.53870E-02
VA2520       22269       22270 AC   0.00000E+00
LA2520       22268       22269      0.12767E-08
CA2521       22274           0      0.94876E-15
RA2521       22274           0      0.41938E+09
RA2522       22273       22274      0.53870E-02
VA2522       22272       22273 AC   0.00000E+00
LA2522       22271       22272      0.12767E-08
CA2523       22277           0      0.94876E-15
RA2523       22277           0      0.41938E+09
RA2524       22276       22277      0.53870E-02
VA2524       22275       22276 AC   0.00000E+00
LA2524       22274       22275      0.12767E-08
CA2525       22280           0      0.94876E-15
RA2525       22280           0      0.41938E+09
RA2526       22279       22280      0.53870E-02
VA2526       22278       22279 AC   0.00000E+00
LA2526       22277       22278      0.12767E-08
CA2527       22283           0      0.94876E-15
RA2527       22283           0      0.41938E+09
RA2528       22282       22283      0.53870E-02
VA2528       22281       22282 AC   0.00000E+00
LA2528       22280       22281      0.12767E-08
CA2529       22286           0      0.49647E-14
RA2529       22286           0      0.41938E+09
RA2530       22285       22286      0.53870E-02
VA2530       22284       22285 AC   0.00000E+00
LA2530       22283       22284      0.12767E-08
CA2531       22287           0      0.50472E-14
RA2531       22287           0      0.41938E+09
CA2532       22290           0      0.94876E-15
RA2532       22290           0      0.41938E+09
RA2533       22289       22290      0.53870E-02
VA2533       22288       22289 AC   0.00000E+00
LA2533       22287       22288      0.12767E-08
CA2534       22293           0      0.94876E-15
RA2534       22293           0      0.41938E+09
RA2535       22292       22293      0.53870E-02
VA2535       22291       22292 AC   0.00000E+00
LA2535       22290       22291      0.12767E-08
CA2536       22296           0      0.94876E-15
RA2536       22296           0      0.41938E+09
RA2537       22295       22296      0.53870E-02
VA2537       22294       22295 AC   0.00000E+00
LA2537       22293       22294      0.12767E-08
CA2538       22299           0      0.94876E-15
RA2538       22299           0      0.41938E+09
RA2539       22298       22299      0.53870E-02
VA2539       22297       22298 AC   0.00000E+00
LA2539       22296       22297      0.12767E-08
CA2540       22302           0      0.94876E-15
RA2540       22302           0      0.41938E+09
RA2541       22301       22302      0.53870E-02
VA2541       22300       22301 AC   0.00000E+00
LA2541       22299       22300      0.12767E-08
CA2542       22305           0      0.94876E-15
RA2542       22305           0      0.41938E+09
RA2543       22304       22305      0.53870E-02
VA2543       22303       22304 AC   0.00000E+00
LA2543       22302       22303      0.12767E-08
CA2544       22308           0      0.94876E-15
RA2544       22308           0      0.41938E+09
RA2545       22307       22308      0.53870E-02
VA2545       22306       22307 AC   0.00000E+00
LA2545       22305       22306      0.12767E-08
CA2546       22311           0      0.94876E-15
RA2546       22311           0      0.41938E+09
RA2547       22310       22311      0.53870E-02
VA2547       22309       22310 AC   0.00000E+00
LA2547       22308       22309      0.12767E-08
CA2548       22314           0      0.94876E-15
RA2548       22314           0      0.41938E+09
RA2549       22313       22314      0.53870E-02
VA2549       22312       22313 AC   0.00000E+00
LA2549       22311       22312      0.12767E-08
CA2550       22317           0      0.50472E-14
RA2550       22317           0      0.41938E+09
RA2551       22316       22317      0.53870E-02
VA2551       22315       22316 AC   0.00000E+00
LA2551       22314       22315      0.12767E-08
CA2552       22318           0      0.15566E-14
RA2552       22318           0      0.41938E+09
CA2553       22321           0      0.94876E-15
RA2553       22321           0      0.41938E+09
RA2554       22320       22321      0.53870E-02
VA2554       22319       22320 AC   0.00000E+00
LA2554       22318       22319      0.12767E-08
CA2555       22324           0      0.94876E-15
RA2555       22324           0      0.41938E+09
RA2556       22323       22324      0.53870E-02
VA2556       22322       22323 AC   0.00000E+00
LA2556       22321       22322      0.12767E-08
CA2557       22327           0      0.94876E-15
RA2557       22327           0      0.41938E+09
RA2558       22326       22327      0.53870E-02
VA2558       22325       22326 AC   0.00000E+00
LA2558       22324       22325      0.12767E-08
CA2559       22330           0      0.94876E-15
RA2559       22330           0      0.41938E+09
RA2560       22329       22330      0.53870E-02
VA2560       22328       22329 AC   0.00000E+00
LA2560       22327       22328      0.12767E-08
CA2561       22333           0      0.94876E-15
RA2561       22333           0      0.41938E+09
RA2562       22332       22333      0.53870E-02
VA2562       22331       22332 AC   0.00000E+00
LA2562       22330       22331      0.12767E-08
CA2563       22336           0      0.49647E-14
RA2563       22336           0      0.41938E+09
RA2564       22335       22336      0.53870E-02
VA2564       22334       22335 AC   0.00000E+00
LA2564       22333       22334      0.12767E-08
CA2565       22337           0      0.50472E-14
RA2565       22337           0      0.41938E+09
CA2566       22340           0      0.94876E-15
RA2566       22340           0      0.41938E+09
RA2567       22339       22340      0.53870E-02
VA2567       22338       22339 AC   0.00000E+00
LA2567       22337       22338      0.12767E-08
CA2568       22343           0      0.94876E-15
RA2568       22343           0      0.41938E+09
RA2569       22342       22343      0.53870E-02
VA2569       22341       22342 AC   0.00000E+00
LA2569       22340       22341      0.12767E-08
CA2570       22346           0      0.94876E-15
RA2570       22346           0      0.41938E+09
RA2571       22345       22346      0.53870E-02
VA2571       22344       22345 AC   0.00000E+00
LA2571       22343       22344      0.12767E-08
CA2572       22349           0      0.94876E-15
RA2572       22349           0      0.41938E+09
RA2573       22348       22349      0.53870E-02
VA2573       22347       22348 AC   0.00000E+00
LA2573       22346       22347      0.12767E-08
CA2574       22352           0      0.94876E-15
RA2574       22352           0      0.41938E+09
RA2575       22351       22352      0.53870E-02
VA2575       22350       22351 AC   0.00000E+00
LA2575       22349       22350      0.12767E-08
CA2576       22355           0      0.94876E-15
RA2576       22355           0      0.41938E+09
RA2577       22354       22355      0.53870E-02
VA2577       22353       22354 AC   0.00000E+00
LA2577       22352       22353      0.12767E-08
CA2578       22358           0      0.94876E-15
RA2578       22358           0      0.41938E+09
RA2579       22357       22358      0.53870E-02
VA2579       22356       22357 AC   0.00000E+00
LA2579       22355       22356      0.12767E-08
CA2580       22361           0      0.94876E-15
RA2580       22361           0      0.41938E+09
RA2581       22360       22361      0.53870E-02
VA2581       22359       22360 AC   0.00000E+00
LA2581       22358       22359      0.12767E-08
CA2582       22364           0      0.94876E-15
RA2582       22364           0      0.41938E+09
RA2583       22363       22364      0.53870E-02
VA2583       22362       22363 AC   0.00000E+00
LA2583       22361       22362      0.12767E-08
CA2584       22367           0      0.50472E-14
RA2584       22367           0      0.41938E+09
RA2585       22366       22367      0.53870E-02
VA2585       22365       22366 AC   0.00000E+00
LA2585       22364       22365      0.12767E-08
CA2586       22368           0      0.15566E-14
RA2586       22368           0      0.41938E+09
CA2587       22371           0      0.94876E-15
RA2587       22371           0      0.41938E+09
RA2588       22370       22371      0.53870E-02
VA2588       22369       22370 AC   0.00000E+00
LA2588       22368       22369      0.12767E-08
CA2589       22374           0      0.94876E-15
RA2589       22374           0      0.41938E+09
RA2590       22373       22374      0.53870E-02
VA2590       22372       22373 AC   0.00000E+00
LA2590       22371       22372      0.12767E-08
CA2591       22377           0      0.94876E-15
RA2591       22377           0      0.41938E+09
RA2592       22376       22377      0.53870E-02
VA2592       22375       22376 AC   0.00000E+00
LA2592       22374       22375      0.12767E-08
CA2593       22380           0      0.94876E-15
RA2593       22380           0      0.41938E+09
RA2594       22379       22380      0.53870E-02
VA2594       22378       22379 AC   0.00000E+00
LA2594       22377       22378      0.12767E-08
CA2595       22383           0      0.94876E-15
RA2595       22383           0      0.41938E+09
RA2596       22382       22383      0.53870E-02
VA2596       22381       22382 AC   0.00000E+00
LA2596       22380       22381      0.12767E-08
CA2597       22386           0      0.49647E-14
RA2597       22386           0      0.41938E+09
RA2598       22385       22386      0.53870E-02
VA2598       22384       22385 AC   0.00000E+00
LA2598       22383       22384      0.12767E-08
CA2599       22387           0      0.50472E-14
RA2599       22387           0      0.41938E+09
CA2600       22390           0      0.94876E-15
RA2600       22390           0      0.41938E+09
RA2601       22389       22390      0.53870E-02
VA2601       22388       22389 AC   0.00000E+00
LA2601       22387       22388      0.12767E-08
CA2602       22393           0      0.94876E-15
RA2602       22393           0      0.41938E+09
RA2603       22392       22393      0.53870E-02
VA2603       22391       22392 AC   0.00000E+00
LA2603       22390       22391      0.12767E-08
CA2604       22396           0      0.94876E-15
RA2604       22396           0      0.41938E+09
RA2605       22395       22396      0.53870E-02
VA2605       22394       22395 AC   0.00000E+00
LA2605       22393       22394      0.12767E-08
CA2606       22399           0      0.94876E-15
RA2606       22399           0      0.41938E+09
RA2607       22398       22399      0.53870E-02
VA2607       22397       22398 AC   0.00000E+00
LA2607       22396       22397      0.12767E-08
CA2608       22402           0      0.94876E-15
RA2608       22402           0      0.41938E+09
RA2609       22401       22402      0.53870E-02
VA2609       22400       22401 AC   0.00000E+00
LA2609       22399       22400      0.12767E-08
CA2610       22405           0      0.94876E-15
RA2610       22405           0      0.41938E+09
RA2611       22404       22405      0.53870E-02
VA2611       22403       22404 AC   0.00000E+00
LA2611       22402       22403      0.12767E-08
CA2612       22408           0      0.94876E-15
RA2612       22408           0      0.41938E+09
RA2613       22407       22408      0.53870E-02
VA2613       22406       22407 AC   0.00000E+00
LA2613       22405       22406      0.12767E-08
CA2614       22411           0      0.94876E-15
RA2614       22411           0      0.41938E+09
RA2615       22410       22411      0.53870E-02
VA2615       22409       22410 AC   0.00000E+00
LA2615       22408       22409      0.12767E-08
CA2616       22414           0      0.94876E-15
RA2616       22414           0      0.41938E+09
RA2617       22413       22414      0.53870E-02
VA2617       22412       22413 AC   0.00000E+00
LA2617       22411       22412      0.12767E-08
CA2618       22417           0      0.50472E-14
RA2618       22417           0      0.41938E+09
RA2619       22416       22417      0.53870E-02
VA2619       22415       22416 AC   0.00000E+00
LA2619       22414       22415      0.12767E-08
CA2620       22418           0      0.15566E-14
RA2620       22418           0      0.41938E+09
CA2621       22421           0      0.94876E-15
RA2621       22421           0      0.41938E+09
RA2622       22420       22421      0.53870E-02
VA2622       22419       22420 AC   0.00000E+00
LA2622       22418       22419      0.12767E-08
CA2623       22424           0      0.94876E-15
RA2623       22424           0      0.41938E+09
RA2624       22423       22424      0.53870E-02
VA2624       22422       22423 AC   0.00000E+00
LA2624       22421       22422      0.12767E-08
CA2625       22427           0      0.94876E-15
RA2625       22427           0      0.41938E+09
RA2626       22426       22427      0.53870E-02
VA2626       22425       22426 AC   0.00000E+00
LA2626       22424       22425      0.12767E-08
CA2627       22430           0      0.94876E-15
RA2627       22430           0      0.41938E+09
RA2628       22429       22430      0.53870E-02
VA2628       22428       22429 AC   0.00000E+00
LA2628       22427       22428      0.12767E-08
CA2629       22433           0      0.94876E-15
RA2629       22433           0      0.41938E+09
RA2630       22432       22433      0.53870E-02
VA2630       22431       22432 AC   0.00000E+00
LA2630       22430       22431      0.12767E-08
CA2631       22436           0      0.49647E-14
RA2631       22436           0      0.41938E+09
RA2632       22435       22436      0.53870E-02
VA2632       22434       22435 AC   0.00000E+00
LA2632       22433       22434      0.12767E-08
CA2633       22437           0      0.50472E-14
RA2633       22437           0      0.41938E+09
CA2634       22440           0      0.94876E-15
RA2634       22440           0      0.41938E+09
RA2635       22439       22440      0.53870E-02
VA2635       22438       22439 AC   0.00000E+00
LA2635       22437       22438      0.12767E-08
CA2636       22443           0      0.94876E-15
RA2636       22443           0      0.41938E+09
RA2637       22442       22443      0.53870E-02
VA2637       22441       22442 AC   0.00000E+00
LA2637       22440       22441      0.12767E-08
CA2638       22446           0      0.94876E-15
RA2638       22446           0      0.41938E+09
RA2639       22445       22446      0.53870E-02
VA2639       22444       22445 AC   0.00000E+00
LA2639       22443       22444      0.12767E-08
CA2640       22449           0      0.94876E-15
RA2640       22449           0      0.41938E+09
RA2641       22448       22449      0.53870E-02
VA2641       22447       22448 AC   0.00000E+00
LA2641       22446       22447      0.12767E-08
CA2642       22452           0      0.94876E-15
RA2642       22452           0      0.41938E+09
RA2643       22451       22452      0.53870E-02
VA2643       22450       22451 AC   0.00000E+00
LA2643       22449       22450      0.12767E-08
CA2644       22455           0      0.94876E-15
RA2644       22455           0      0.41938E+09
RA2645       22454       22455      0.53870E-02
VA2645       22453       22454 AC   0.00000E+00
LA2645       22452       22453      0.12767E-08
CA2646       22458           0      0.94876E-15
RA2646       22458           0      0.41938E+09
RA2647       22457       22458      0.53870E-02
VA2647       22456       22457 AC   0.00000E+00
LA2647       22455       22456      0.12767E-08
CA2648       22461           0      0.94876E-15
RA2648       22461           0      0.41938E+09
RA2649       22460       22461      0.53870E-02
VA2649       22459       22460 AC   0.00000E+00
LA2649       22458       22459      0.12767E-08
CA2650       22464           0      0.94876E-15
RA2650       22464           0      0.41938E+09
RA2651       22463       22464      0.53870E-02
VA2651       22462       22463 AC   0.00000E+00
LA2651       22461       22462      0.12767E-08
CA2652       22467           0      0.50472E-14
RA2652       22467           0      0.41938E+09
RA2653       22466       22467      0.53870E-02
VA2653       22465       22466 AC   0.00000E+00
LA2653       22464       22465      0.12767E-08
CA2654       22468           0      0.15566E-14
RA2654       22468           0      0.41938E+09
CA2655       22471           0      0.94876E-15
RA2655       22471           0      0.41938E+09
RA2656       22470       22471      0.53870E-02
VA2656       22469       22470 AC   0.00000E+00
LA2656       22468       22469      0.12767E-08
CA2657       22474           0      0.94876E-15
RA2657       22474           0      0.41938E+09
RA2658       22473       22474      0.53870E-02
VA2658       22472       22473 AC   0.00000E+00
LA2658       22471       22472      0.12767E-08
CA2659       22477           0      0.94876E-15
RA2659       22477           0      0.41938E+09
RA2660       22476       22477      0.53870E-02
VA2660       22475       22476 AC   0.00000E+00
LA2660       22474       22475      0.12767E-08
CA2661       22480           0      0.94876E-15
RA2661       22480           0      0.41938E+09
RA2662       22479       22480      0.53870E-02
VA2662       22478       22479 AC   0.00000E+00
LA2662       22477       22478      0.12767E-08
CA2663       22483           0      0.94876E-15
RA2663       22483           0      0.41938E+09
RA2664       22482       22483      0.53870E-02
VA2664       22481       22482 AC   0.00000E+00
LA2664       22480       22481      0.12767E-08
CA2665       22486           0      0.49647E-14
RA2665       22486           0      0.41938E+09
RA2666       22485       22486      0.53870E-02
VA2666       22484       22485 AC   0.00000E+00
LA2666       22483       22484      0.12767E-08
CA2667       22487           0      0.50472E-14
RA2667       22487           0      0.41938E+09
CA2668       22490           0      0.94876E-15
RA2668       22490           0      0.41938E+09
RA2669       22489       22490      0.53870E-02
VA2669       22488       22489 AC   0.00000E+00
LA2669       22487       22488      0.12767E-08
CA2670       22493           0      0.94876E-15
RA2670       22493           0      0.41938E+09
RA2671       22492       22493      0.53870E-02
VA2671       22491       22492 AC   0.00000E+00
LA2671       22490       22491      0.12767E-08
CA2672       22496           0      0.94876E-15
RA2672       22496           0      0.41938E+09
RA2673       22495       22496      0.53870E-02
VA2673       22494       22495 AC   0.00000E+00
LA2673       22493       22494      0.12767E-08
CA2674       22499           0      0.94876E-15
RA2674       22499           0      0.41938E+09
RA2675       22498       22499      0.53870E-02
VA2675       22497       22498 AC   0.00000E+00
LA2675       22496       22497      0.12767E-08
CA2676       22502           0      0.94876E-15
RA2676       22502           0      0.41938E+09
RA2677       22501       22502      0.53870E-02
VA2677       22500       22501 AC   0.00000E+00
LA2677       22499       22500      0.12767E-08
CA2678       22505           0      0.94876E-15
RA2678       22505           0      0.41938E+09
RA2679       22504       22505      0.53870E-02
VA2679       22503       22504 AC   0.00000E+00
LA2679       22502       22503      0.12767E-08
CA2680       22508           0      0.94876E-15
RA2680       22508           0      0.41938E+09
RA2681       22507       22508      0.53870E-02
VA2681       22506       22507 AC   0.00000E+00
LA2681       22505       22506      0.12767E-08
CA2682       22511           0      0.94876E-15
RA2682       22511           0      0.41938E+09
RA2683       22510       22511      0.53870E-02
VA2683       22509       22510 AC   0.00000E+00
LA2683       22508       22509      0.12767E-08
CA2684       22514           0      0.94876E-15
RA2684       22514           0      0.41938E+09
RA2685       22513       22514      0.53870E-02
VA2685       22512       22513 AC   0.00000E+00
LA2685       22511       22512      0.12767E-08
CA2686       22517           0      0.50472E-14
RA2686       22517           0      0.41938E+09
RA2687       22516       22517      0.53870E-02
VA2687       22515       22516 AC   0.00000E+00
LA2687       22514       22515      0.12767E-08
CA2688       22518           0      0.15566E-14
RA2688       22518           0      0.41938E+09
CA2689       22521           0      0.94876E-15
RA2689       22521           0      0.41938E+09
RA2690       22520       22521      0.53870E-02
VA2690       22519       22520 AC   0.00000E+00
LA2690       22518       22519      0.12767E-08
CA2691       22524           0      0.94876E-15
RA2691       22524           0      0.41938E+09
RA2692       22523       22524      0.53870E-02
VA2692       22522       22523 AC   0.00000E+00
LA2692       22521       22522      0.12767E-08
CA2693       22527           0      0.94876E-15
RA2693       22527           0      0.41938E+09
RA2694       22526       22527      0.53870E-02
VA2694       22525       22526 AC   0.00000E+00
LA2694       22524       22525      0.12767E-08
CA2695       22530           0      0.94876E-15
RA2695       22530           0      0.41938E+09
RA2696       22529       22530      0.53870E-02
VA2696       22528       22529 AC   0.00000E+00
LA2696       22527       22528      0.12767E-08
CA2697       22533           0      0.94876E-15
RA2697       22533           0      0.41938E+09
RA2698       22532       22533      0.53870E-02
VA2698       22531       22532 AC   0.00000E+00
LA2698       22530       22531      0.12767E-08
CA2699       22536           0      0.49647E-14
RA2699       22536           0      0.41938E+09
RA2700       22535       22536      0.53870E-02
VA2700       22534       22535 AC   0.00000E+00
LA2700       22533       22534      0.12767E-08
CA2701       22537           0      0.50472E-14
RA2701       22537           0      0.41938E+09
CA2702       22540           0      0.94876E-15
RA2702       22540           0      0.41938E+09
RA2703       22539       22540      0.53870E-02
VA2703       22538       22539 AC   0.00000E+00
LA2703       22537       22538      0.12767E-08
CA2704       22543           0      0.94876E-15
RA2704       22543           0      0.41938E+09
RA2705       22542       22543      0.53870E-02
VA2705       22541       22542 AC   0.00000E+00
LA2705       22540       22541      0.12767E-08
CA2706       22546           0      0.94876E-15
RA2706       22546           0      0.41938E+09
RA2707       22545       22546      0.53870E-02
VA2707       22544       22545 AC   0.00000E+00
LA2707       22543       22544      0.12767E-08
CA2708       22549           0      0.94876E-15
RA2708       22549           0      0.41938E+09
RA2709       22548       22549      0.53870E-02
VA2709       22547       22548 AC   0.00000E+00
LA2709       22546       22547      0.12767E-08
CA2710       22552           0      0.94876E-15
RA2710       22552           0      0.41938E+09
RA2711       22551       22552      0.53870E-02
VA2711       22550       22551 AC   0.00000E+00
LA2711       22549       22550      0.12767E-08
CA2712       22555           0      0.94876E-15
RA2712       22555           0      0.41938E+09
RA2713       22554       22555      0.53870E-02
VA2713       22553       22554 AC   0.00000E+00
LA2713       22552       22553      0.12767E-08
CA2714       22558           0      0.94876E-15
RA2714       22558           0      0.41938E+09
RA2715       22557       22558      0.53870E-02
VA2715       22556       22557 AC   0.00000E+00
LA2715       22555       22556      0.12767E-08
CA2716       22561           0      0.94876E-15
RA2716       22561           0      0.41938E+09
RA2717       22560       22561      0.53870E-02
VA2717       22559       22560 AC   0.00000E+00
LA2717       22558       22559      0.12767E-08
CA2718       22564           0      0.94876E-15
RA2718       22564           0      0.41938E+09
RA2719       22563       22564      0.53870E-02
VA2719       22562       22563 AC   0.00000E+00
LA2719       22561       22562      0.12767E-08
CA2720       22567           0      0.50472E-14
RA2720       22567           0      0.41938E+09
RA2721       22566       22567      0.53870E-02
VA2721       22565       22566 AC   0.00000E+00
LA2721       22564       22565      0.12767E-08
CA2722       22568           0      0.15566E-14
RA2722       22568           0      0.41938E+09
CA2723       22571           0      0.94876E-15
RA2723       22571           0      0.41938E+09
RA2724       22570       22571      0.53870E-02
VA2724       22569       22570 AC   0.00000E+00
LA2724       22568       22569      0.12767E-08
CA2725       22574           0      0.94876E-15
RA2725       22574           0      0.41938E+09
RA2726       22573       22574      0.53870E-02
VA2726       22572       22573 AC   0.00000E+00
LA2726       22571       22572      0.12767E-08
CA2727       22577           0      0.94876E-15
RA2727       22577           0      0.41938E+09
RA2728       22576       22577      0.53870E-02
VA2728       22575       22576 AC   0.00000E+00
LA2728       22574       22575      0.12767E-08
CA2729       22580           0      0.94876E-15
RA2729       22580           0      0.41938E+09
RA2730       22579       22580      0.53870E-02
VA2730       22578       22579 AC   0.00000E+00
LA2730       22577       22578      0.12767E-08
CA2731       22583           0      0.94876E-15
RA2731       22583           0      0.41938E+09
RA2732       22582       22583      0.53870E-02
VA2732       22581       22582 AC   0.00000E+00
LA2732       22580       22581      0.12767E-08
CA2733       22586           0      0.49647E-14
RA2733       22586           0      0.41938E+09
RA2734       22585       22586      0.53870E-02
VA2734       22584       22585 AC   0.00000E+00
LA2734       22583       22584      0.12767E-08
CA2735       22587           0      0.50472E-14
RA2735       22587           0      0.41938E+09
CA2736       22590           0      0.94876E-15
RA2736       22590           0      0.41938E+09
RA2737       22589       22590      0.53870E-02
VA2737       22588       22589 AC   0.00000E+00
LA2737       22587       22588      0.12767E-08
CA2738       22593           0      0.94876E-15
RA2738       22593           0      0.41938E+09
RA2739       22592       22593      0.53870E-02
VA2739       22591       22592 AC   0.00000E+00
LA2739       22590       22591      0.12767E-08
CA2740       22596           0      0.94876E-15
RA2740       22596           0      0.41938E+09
RA2741       22595       22596      0.53870E-02
VA2741       22594       22595 AC   0.00000E+00
LA2741       22593       22594      0.12767E-08
CA2742       22599           0      0.94876E-15
RA2742       22599           0      0.41938E+09
RA2743       22598       22599      0.53870E-02
VA2743       22597       22598 AC   0.00000E+00
LA2743       22596       22597      0.12767E-08
CA2744       22602           0      0.94876E-15
RA2744       22602           0      0.41938E+09
RA2745       22601       22602      0.53870E-02
VA2745       22600       22601 AC   0.00000E+00
LA2745       22599       22600      0.12767E-08
CA2746       22605           0      0.94876E-15
RA2746       22605           0      0.41938E+09
RA2747       22604       22605      0.53870E-02
VA2747       22603       22604 AC   0.00000E+00
LA2747       22602       22603      0.12767E-08
CA2748       22608           0      0.94876E-15
RA2748       22608           0      0.41938E+09
RA2749       22607       22608      0.53870E-02
VA2749       22606       22607 AC   0.00000E+00
LA2749       22605       22606      0.12767E-08
CA2750       22611           0      0.94876E-15
RA2750       22611           0      0.41938E+09
RA2751       22610       22611      0.53870E-02
VA2751       22609       22610 AC   0.00000E+00
LA2751       22608       22609      0.12767E-08
CA2752       22614           0      0.94876E-15
RA2752       22614           0      0.41938E+09
RA2753       22613       22614      0.53870E-02
VA2753       22612       22613 AC   0.00000E+00
LA2753       22611       22612      0.12767E-08
CA2754       22617           0      0.50472E-14
RA2754       22617           0      0.41938E+09
RA2755       22616       22617      0.53870E-02
VA2755       22615       22616 AC   0.00000E+00
LA2755       22614       22615      0.12767E-08
CA2756       22618           0      0.15566E-14
RA2756       22618           0      0.41938E+09
CA2757       22621           0      0.94876E-15
RA2757       22621           0      0.41938E+09
RA2758       22620       22621      0.53870E-02
VA2758       22619       22620 AC   0.00000E+00
LA2758       22618       22619      0.12767E-08
CA2759       22624           0      0.94876E-15
RA2759       22624           0      0.41938E+09
RA2760       22623       22624      0.53870E-02
VA2760       22622       22623 AC   0.00000E+00
LA2760       22621       22622      0.12767E-08
CA2761       22627           0      0.94876E-15
RA2761       22627           0      0.41938E+09
RA2762       22626       22627      0.53870E-02
VA2762       22625       22626 AC   0.00000E+00
LA2762       22624       22625      0.12767E-08
CA2763       22630           0      0.94876E-15
RA2763       22630           0      0.41938E+09
RA2764       22629       22630      0.53870E-02
VA2764       22628       22629 AC   0.00000E+00
LA2764       22627       22628      0.12767E-08
CA2765       22633           0      0.94876E-15
RA2765       22633           0      0.41938E+09
RA2766       22632       22633      0.53870E-02
VA2766       22631       22632 AC   0.00000E+00
LA2766       22630       22631      0.12767E-08
CA2767       22636           0      0.49647E-14
RA2767       22636           0      0.41938E+09
RA2768       22635       22636      0.53870E-02
VA2768       22634       22635 AC   0.00000E+00
LA2768       22633       22634      0.12767E-08
CA2769       22637           0      0.50472E-14
RA2769       22637           0      0.41938E+09
CA2770       22640           0      0.94876E-15
RA2770       22640           0      0.41938E+09
RA2771       22639       22640      0.53870E-02
VA2771       22638       22639 AC   0.00000E+00
LA2771       22637       22638      0.12767E-08
CA2772       22643           0      0.94876E-15
RA2772       22643           0      0.41938E+09
RA2773       22642       22643      0.53870E-02
VA2773       22641       22642 AC   0.00000E+00
LA2773       22640       22641      0.12767E-08
CA2774       22646           0      0.94876E-15
RA2774       22646           0      0.41938E+09
RA2775       22645       22646      0.53870E-02
VA2775       22644       22645 AC   0.00000E+00
LA2775       22643       22644      0.12767E-08
CA2776       22649           0      0.94876E-15
RA2776       22649           0      0.41938E+09
RA2777       22648       22649      0.53870E-02
VA2777       22647       22648 AC   0.00000E+00
LA2777       22646       22647      0.12767E-08
CA2778       22652           0      0.94876E-15
RA2778       22652           0      0.41938E+09
RA2779       22651       22652      0.53870E-02
VA2779       22650       22651 AC   0.00000E+00
LA2779       22649       22650      0.12767E-08
CA2780       22655           0      0.94876E-15
RA2780       22655           0      0.41938E+09
RA2781       22654       22655      0.53870E-02
VA2781       22653       22654 AC   0.00000E+00
LA2781       22652       22653      0.12767E-08
CA2782       22658           0      0.94876E-15
RA2782       22658           0      0.41938E+09
RA2783       22657       22658      0.53870E-02
VA2783       22656       22657 AC   0.00000E+00
LA2783       22655       22656      0.12767E-08
CA2784       22661           0      0.94876E-15
RA2784       22661           0      0.41938E+09
RA2785       22660       22661      0.53870E-02
VA2785       22659       22660 AC   0.00000E+00
LA2785       22658       22659      0.12767E-08
CA2786       22664           0      0.94876E-15
RA2786       22664           0      0.41938E+09
RA2787       22663       22664      0.53870E-02
VA2787       22662       22663 AC   0.00000E+00
LA2787       22661       22662      0.12767E-08
CA2788       22667           0      0.50472E-14
RA2788       22667           0      0.41938E+09
RA2789       22666       22667      0.53870E-02
VA2789       22665       22666 AC   0.00000E+00
LA2789       22664       22665      0.12767E-08
CA2790       22668           0      0.15566E-14
RA2790       22668           0      0.41938E+09
CA2791       22671           0      0.94876E-15
RA2791       22671           0      0.41938E+09
RA2792       22670       22671      0.53870E-02
VA2792       22669       22670 AC   0.00000E+00
LA2792       22668       22669      0.12767E-08
CA2793       22674           0      0.94876E-15
RA2793       22674           0      0.41938E+09
RA2794       22673       22674      0.53870E-02
VA2794       22672       22673 AC   0.00000E+00
LA2794       22671       22672      0.12767E-08
CA2795       22677           0      0.94876E-15
RA2795       22677           0      0.41938E+09
RA2796       22676       22677      0.53870E-02
VA2796       22675       22676 AC   0.00000E+00
LA2796       22674       22675      0.12767E-08
CA2797       22680           0      0.94876E-15
RA2797       22680           0      0.41938E+09
RA2798       22679       22680      0.53870E-02
VA2798       22678       22679 AC   0.00000E+00
LA2798       22677       22678      0.12767E-08
CA2799       22683           0      0.94876E-15
RA2799       22683           0      0.41938E+09
RA2800       22682       22683      0.53870E-02
VA2800       22681       22682 AC   0.00000E+00
LA2800       22680       22681      0.12767E-08
CA2801       22686           0      0.49647E-14
RA2801       22686           0      0.41938E+09
RA2802       22685       22686      0.53870E-02
VA2802       22684       22685 AC   0.00000E+00
LA2802       22683       22684      0.12767E-08
CA2803       22687           0      0.50472E-14
RA2803       22687           0      0.41938E+09
CA2804       22690           0      0.94876E-15
RA2804       22690           0      0.41938E+09
RA2805       22689       22690      0.53870E-02
VA2805       22688       22689 AC   0.00000E+00
LA2805       22687       22688      0.12767E-08
CA2806       22693           0      0.94876E-15
RA2806       22693           0      0.41938E+09
RA2807       22692       22693      0.53870E-02
VA2807       22691       22692 AC   0.00000E+00
LA2807       22690       22691      0.12767E-08
CA2808       22696           0      0.94876E-15
RA2808       22696           0      0.41938E+09
RA2809       22695       22696      0.53870E-02
VA2809       22694       22695 AC   0.00000E+00
LA2809       22693       22694      0.12767E-08
CA2810       22699           0      0.94876E-15
RA2810       22699           0      0.41938E+09
RA2811       22698       22699      0.53870E-02
VA2811       22697       22698 AC   0.00000E+00
LA2811       22696       22697      0.12767E-08
CA2812       22702           0      0.94876E-15
RA2812       22702           0      0.41938E+09
RA2813       22701       22702      0.53870E-02
VA2813       22700       22701 AC   0.00000E+00
LA2813       22699       22700      0.12767E-08
CA2814       22705           0      0.94876E-15
RA2814       22705           0      0.41938E+09
RA2815       22704       22705      0.53870E-02
VA2815       22703       22704 AC   0.00000E+00
LA2815       22702       22703      0.12767E-08
CA2816       22708           0      0.94876E-15
RA2816       22708           0      0.41938E+09
RA2817       22707       22708      0.53870E-02
VA2817       22706       22707 AC   0.00000E+00
LA2817       22705       22706      0.12767E-08
CA2818       22711           0      0.94876E-15
RA2818       22711           0      0.41938E+09
RA2819       22710       22711      0.53870E-02
VA2819       22709       22710 AC   0.00000E+00
LA2819       22708       22709      0.12767E-08
CA2820       22714           0      0.94876E-15
RA2820       22714           0      0.41938E+09
RA2821       22713       22714      0.53870E-02
VA2821       22712       22713 AC   0.00000E+00
LA2821       22711       22712      0.12767E-08
CA2822       22717           0      0.50472E-14
RA2822       22717           0      0.41938E+09
RA2823       22716       22717      0.53870E-02
VA2823       22715       22716 AC   0.00000E+00
LA2823       22714       22715      0.12767E-08
CA2824       22718           0      0.15566E-14
RA2824       22718           0      0.41938E+09
CA2825       22721           0      0.94876E-15
RA2825       22721           0      0.41938E+09
RA2826       22720       22721      0.53870E-02
VA2826       22719       22720 AC   0.00000E+00
LA2826       22718       22719      0.12767E-08
CA2827       22724           0      0.94876E-15
RA2827       22724           0      0.41938E+09
RA2828       22723       22724      0.53870E-02
VA2828       22722       22723 AC   0.00000E+00
LA2828       22721       22722      0.12767E-08
CA2829       22727           0      0.94876E-15
RA2829       22727           0      0.41938E+09
RA2830       22726       22727      0.53870E-02
VA2830       22725       22726 AC   0.00000E+00
LA2830       22724       22725      0.12767E-08
CA2831       22730           0      0.94876E-15
RA2831       22730           0      0.41938E+09
RA2832       22729       22730      0.53870E-02
VA2832       22728       22729 AC   0.00000E+00
LA2832       22727       22728      0.12767E-08
CA2833       22733           0      0.94876E-15
RA2833       22733           0      0.41938E+09
RA2834       22732       22733      0.53870E-02
VA2834       22731       22732 AC   0.00000E+00
LA2834       22730       22731      0.12767E-08
CA2835       22736           0      0.49647E-14
RA2835       22736           0      0.41938E+09
RA2836       22735       22736      0.53870E-02
VA2836       22734       22735 AC   0.00000E+00
LA2836       22733       22734      0.12767E-08
CA2837       22737           0      0.50472E-14
RA2837       22737           0      0.41938E+09
CA2838       22740           0      0.94876E-15
RA2838       22740           0      0.41938E+09
RA2839       22739       22740      0.53870E-02
VA2839       22738       22739 AC   0.00000E+00
LA2839       22737       22738      0.12767E-08
CA2840       22743           0      0.94876E-15
RA2840       22743           0      0.41938E+09
RA2841       22742       22743      0.53870E-02
VA2841       22741       22742 AC   0.00000E+00
LA2841       22740       22741      0.12767E-08
CA2842       22746           0      0.94876E-15
RA2842       22746           0      0.41938E+09
RA2843       22745       22746      0.53870E-02
VA2843       22744       22745 AC   0.00000E+00
LA2843       22743       22744      0.12767E-08
CA2844       22749           0      0.94876E-15
RA2844       22749           0      0.41938E+09
RA2845       22748       22749      0.53870E-02
VA2845       22747       22748 AC   0.00000E+00
LA2845       22746       22747      0.12767E-08
CA2846       22752           0      0.94876E-15
RA2846       22752           0      0.41938E+09
RA2847       22751       22752      0.53870E-02
VA2847       22750       22751 AC   0.00000E+00
LA2847       22749       22750      0.12767E-08
CA2848       22755           0      0.94876E-15
RA2848       22755           0      0.41938E+09
RA2849       22754       22755      0.53870E-02
VA2849       22753       22754 AC   0.00000E+00
LA2849       22752       22753      0.12767E-08
CA2850       22758           0      0.94876E-15
RA2850       22758           0      0.41938E+09
RA2851       22757       22758      0.53870E-02
VA2851       22756       22757 AC   0.00000E+00
LA2851       22755       22756      0.12767E-08
CA2852       22761           0      0.94876E-15
RA2852       22761           0      0.41938E+09
RA2853       22760       22761      0.53870E-02
VA2853       22759       22760 AC   0.00000E+00
LA2853       22758       22759      0.12767E-08
CA2854       22764           0      0.94876E-15
RA2854       22764           0      0.41938E+09
RA2855       22763       22764      0.53870E-02
VA2855       22762       22763 AC   0.00000E+00
LA2855       22761       22762      0.12767E-08
CA2856       22767           0      0.50472E-14
RA2856       22767           0      0.41938E+09
RA2857       22766       22767      0.53870E-02
VA2857       22765       22766 AC   0.00000E+00
LA2857       22764       22765      0.12767E-08
CA2858       22768           0      0.15566E-14
RA2858       22768           0      0.41938E+09
CA2859       22771           0      0.94876E-15
RA2859       22771           0      0.41938E+09
RA2860       22770       22771      0.53870E-02
VA2860       22769       22770 AC   0.00000E+00
LA2860       22768       22769      0.12767E-08
CA2861       22774           0      0.94876E-15
RA2861       22774           0      0.41938E+09
RA2862       22773       22774      0.53870E-02
VA2862       22772       22773 AC   0.00000E+00
LA2862       22771       22772      0.12767E-08
CA2863       22777           0      0.94876E-15
RA2863       22777           0      0.41938E+09
RA2864       22776       22777      0.53870E-02
VA2864       22775       22776 AC   0.00000E+00
LA2864       22774       22775      0.12767E-08
CA2865       22780           0      0.94876E-15
RA2865       22780           0      0.41938E+09
RA2866       22779       22780      0.53870E-02
VA2866       22778       22779 AC   0.00000E+00
LA2866       22777       22778      0.12767E-08
CA2867       22783           0      0.94876E-15
RA2867       22783           0      0.41938E+09
RA2868       22782       22783      0.53870E-02
VA2868       22781       22782 AC   0.00000E+00
LA2868       22780       22781      0.12767E-08
CA2869       22786           0      0.49647E-14
RA2869       22786           0      0.41938E+09
RA2870       22785       22786      0.53870E-02
VA2870       22784       22785 AC   0.00000E+00
LA2870       22783       22784      0.12767E-08
CA2871       22787           0      0.50472E-14
RA2871       22787           0      0.41938E+09
CA2872       22790           0      0.94876E-15
RA2872       22790           0      0.41938E+09
RA2873       22789       22790      0.53870E-02
VA2873       22788       22789 AC   0.00000E+00
LA2873       22787       22788      0.12767E-08
CA2874       22793           0      0.94876E-15
RA2874       22793           0      0.41938E+09
RA2875       22792       22793      0.53870E-02
VA2875       22791       22792 AC   0.00000E+00
LA2875       22790       22791      0.12767E-08
CA2876       22796           0      0.94876E-15
RA2876       22796           0      0.41938E+09
RA2877       22795       22796      0.53870E-02
VA2877       22794       22795 AC   0.00000E+00
LA2877       22793       22794      0.12767E-08
CA2878       22799           0      0.94876E-15
RA2878       22799           0      0.41938E+09
RA2879       22798       22799      0.53870E-02
VA2879       22797       22798 AC   0.00000E+00
LA2879       22796       22797      0.12767E-08
CA2880       22802           0      0.94876E-15
RA2880       22802           0      0.41938E+09
RA2881       22801       22802      0.53870E-02
VA2881       22800       22801 AC   0.00000E+00
LA2881       22799       22800      0.12767E-08
CA2882       22805           0      0.94876E-15
RA2882       22805           0      0.41938E+09
RA2883       22804       22805      0.53870E-02
VA2883       22803       22804 AC   0.00000E+00
LA2883       22802       22803      0.12767E-08
CA2884       22808           0      0.94876E-15
RA2884       22808           0      0.41938E+09
RA2885       22807       22808      0.53870E-02
VA2885       22806       22807 AC   0.00000E+00
LA2885       22805       22806      0.12767E-08
CA2886       22811           0      0.94876E-15
RA2886       22811           0      0.41938E+09
RA2887       22810       22811      0.53870E-02
VA2887       22809       22810 AC   0.00000E+00
LA2887       22808       22809      0.12767E-08
CA2888       22814           0      0.94876E-15
RA2888       22814           0      0.41938E+09
RA2889       22813       22814      0.53870E-02
VA2889       22812       22813 AC   0.00000E+00
LA2889       22811       22812      0.12767E-08
CA2890       22817           0      0.50472E-14
RA2890       22817           0      0.41938E+09
RA2891       22816       22817      0.53870E-02
VA2891       22815       22816 AC   0.00000E+00
LA2891       22814       22815      0.12767E-08
CA2892       22818           0      0.15566E-14
RA2892       22818           0      0.41938E+09
CA2893       22821           0      0.94876E-15
RA2893       22821           0      0.41938E+09
RA2894       22820       22821      0.53870E-02
VA2894       22819       22820 AC   0.00000E+00
LA2894       22818       22819      0.12767E-08
CA2895       22824           0      0.94876E-15
RA2895       22824           0      0.41938E+09
RA2896       22823       22824      0.53870E-02
VA2896       22822       22823 AC   0.00000E+00
LA2896       22821       22822      0.12767E-08
CA2897       22827           0      0.94876E-15
RA2897       22827           0      0.41938E+09
RA2898       22826       22827      0.53870E-02
VA2898       22825       22826 AC   0.00000E+00
LA2898       22824       22825      0.12767E-08
CA2899       22830           0      0.94876E-15
RA2899       22830           0      0.41938E+09
RA2900       22829       22830      0.53870E-02
VA2900       22828       22829 AC   0.00000E+00
LA2900       22827       22828      0.12767E-08
CA2901       22833           0      0.94876E-15
RA2901       22833           0      0.41938E+09
RA2902       22832       22833      0.53870E-02
VA2902       22831       22832 AC   0.00000E+00
LA2902       22830       22831      0.12767E-08
CA2903       22836           0      0.49647E-14
RA2903       22836           0      0.41938E+09
RA2904       22835       22836      0.53870E-02
VA2904       22834       22835 AC   0.00000E+00
LA2904       22833       22834      0.12767E-08
CA2905       22837           0      0.50472E-14
RA2905       22837           0      0.41938E+09
CA2906       22840           0      0.94876E-15
RA2906       22840           0      0.41938E+09
RA2907       22839       22840      0.53870E-02
VA2907       22838       22839 AC   0.00000E+00
LA2907       22837       22838      0.12767E-08
CA2908       22843           0      0.94876E-15
RA2908       22843           0      0.41938E+09
RA2909       22842       22843      0.53870E-02
VA2909       22841       22842 AC   0.00000E+00
LA2909       22840       22841      0.12767E-08
CA2910       22846           0      0.94876E-15
RA2910       22846           0      0.41938E+09
RA2911       22845       22846      0.53870E-02
VA2911       22844       22845 AC   0.00000E+00
LA2911       22843       22844      0.12767E-08
CA2912       22849           0      0.94876E-15
RA2912       22849           0      0.41938E+09
RA2913       22848       22849      0.53870E-02
VA2913       22847       22848 AC   0.00000E+00
LA2913       22846       22847      0.12767E-08
CA2914       22852           0      0.94876E-15
RA2914       22852           0      0.41938E+09
RA2915       22851       22852      0.53870E-02
VA2915       22850       22851 AC   0.00000E+00
LA2915       22849       22850      0.12767E-08
CA2916       22855           0      0.94876E-15
RA2916       22855           0      0.41938E+09
RA2917       22854       22855      0.53870E-02
VA2917       22853       22854 AC   0.00000E+00
LA2917       22852       22853      0.12767E-08
CA2918       22858           0      0.94876E-15
RA2918       22858           0      0.41938E+09
RA2919       22857       22858      0.53870E-02
VA2919       22856       22857 AC   0.00000E+00
LA2919       22855       22856      0.12767E-08
CA2920       22861           0      0.94876E-15
RA2920       22861           0      0.41938E+09
RA2921       22860       22861      0.53870E-02
VA2921       22859       22860 AC   0.00000E+00
LA2921       22858       22859      0.12767E-08
CA2922       22864           0      0.94876E-15
RA2922       22864           0      0.41938E+09
RA2923       22863       22864      0.53870E-02
VA2923       22862       22863 AC   0.00000E+00
LA2923       22861       22862      0.12767E-08
CA2924       22867           0      0.50472E-14
RA2924       22867           0      0.41938E+09
RA2925       22866       22867      0.53870E-02
VA2925       22865       22866 AC   0.00000E+00
LA2925       22864       22865      0.12767E-08
CA2926       22868           0      0.15566E-14
RA2926       22868           0      0.41938E+09
CA2927       22871           0      0.94876E-15
RA2927       22871           0      0.41938E+09
RA2928       22870       22871      0.53870E-02
VA2928       22869       22870 AC   0.00000E+00
LA2928       22868       22869      0.12767E-08
CA2929       22874           0      0.94876E-15
RA2929       22874           0      0.41938E+09
RA2930       22873       22874      0.53870E-02
VA2930       22872       22873 AC   0.00000E+00
LA2930       22871       22872      0.12767E-08
CA2931       22877           0      0.94876E-15
RA2931       22877           0      0.41938E+09
RA2932       22876       22877      0.53870E-02
VA2932       22875       22876 AC   0.00000E+00
LA2932       22874       22875      0.12767E-08
CA2933       22880           0      0.94876E-15
RA2933       22880           0      0.41938E+09
RA2934       22879       22880      0.53870E-02
VA2934       22878       22879 AC   0.00000E+00
LA2934       22877       22878      0.12767E-08
CA2935       22883           0      0.94876E-15
RA2935       22883           0      0.41938E+09
RA2936       22882       22883      0.53870E-02
VA2936       22881       22882 AC   0.00000E+00
LA2936       22880       22881      0.12767E-08
CA2937       22886           0      0.49647E-14
RA2937       22886           0      0.41938E+09
RA2938       22885       22886      0.53870E-02
VA2938       22884       22885 AC   0.00000E+00
LA2938       22883       22884      0.12767E-08
CA2939       22887           0      0.50472E-14
RA2939       22887           0      0.41938E+09
CA2940       22890           0      0.94876E-15
RA2940       22890           0      0.41938E+09
RA2941       22889       22890      0.53870E-02
VA2941       22888       22889 AC   0.00000E+00
LA2941       22887       22888      0.12767E-08
CA2942       22893           0      0.94876E-15
RA2942       22893           0      0.41938E+09
RA2943       22892       22893      0.53870E-02
VA2943       22891       22892 AC   0.00000E+00
LA2943       22890       22891      0.12767E-08
CA2944       22896           0      0.94876E-15
RA2944       22896           0      0.41938E+09
RA2945       22895       22896      0.53870E-02
VA2945       22894       22895 AC   0.00000E+00
LA2945       22893       22894      0.12767E-08
CA2946       22899           0      0.94876E-15
RA2946       22899           0      0.41938E+09
RA2947       22898       22899      0.53870E-02
VA2947       22897       22898 AC   0.00000E+00
LA2947       22896       22897      0.12767E-08
CA2948       22902           0      0.94876E-15
RA2948       22902           0      0.41938E+09
RA2949       22901       22902      0.53870E-02
VA2949       22900       22901 AC   0.00000E+00
LA2949       22899       22900      0.12767E-08
CA2950       22905           0      0.94876E-15
RA2950       22905           0      0.41938E+09
RA2951       22904       22905      0.53870E-02
VA2951       22903       22904 AC   0.00000E+00
LA2951       22902       22903      0.12767E-08
CA2952       22908           0      0.94876E-15
RA2952       22908           0      0.41938E+09
RA2953       22907       22908      0.53870E-02
VA2953       22906       22907 AC   0.00000E+00
LA2953       22905       22906      0.12767E-08
CA2954       22911           0      0.94876E-15
RA2954       22911           0      0.41938E+09
RA2955       22910       22911      0.53870E-02
VA2955       22909       22910 AC   0.00000E+00
LA2955       22908       22909      0.12767E-08
CA2956       22914           0      0.94876E-15
RA2956       22914           0      0.41938E+09
RA2957       22913       22914      0.53870E-02
VA2957       22912       22913 AC   0.00000E+00
LA2957       22911       22912      0.12767E-08
CA2958       22917           0      0.50472E-14
RA2958       22917           0      0.41938E+09
RA2959       22916       22917      0.53870E-02
VA2959       22915       22916 AC   0.00000E+00
LA2959       22914       22915      0.12767E-08
CA2960       22918           0      0.15566E-14
RA2960       22918           0      0.41938E+09
CA2961       22921           0      0.94876E-15
RA2961       22921           0      0.41938E+09
RA2962       22920       22921      0.53870E-02
VA2962       22919       22920 AC   0.00000E+00
LA2962       22918       22919      0.12767E-08
CA2963       22924           0      0.94876E-15
RA2963       22924           0      0.41938E+09
RA2964       22923       22924      0.53870E-02
VA2964       22922       22923 AC   0.00000E+00
LA2964       22921       22922      0.12767E-08
CA2965       22927           0      0.94876E-15
RA2965       22927           0      0.41938E+09
RA2966       22926       22927      0.53870E-02
VA2966       22925       22926 AC   0.00000E+00
LA2966       22924       22925      0.12767E-08
CA2967       22930           0      0.94876E-15
RA2967       22930           0      0.41938E+09
RA2968       22929       22930      0.53870E-02
VA2968       22928       22929 AC   0.00000E+00
LA2968       22927       22928      0.12767E-08
CA2969       22933           0      0.94876E-15
RA2969       22933           0      0.41938E+09
RA2970       22932       22933      0.53870E-02
VA2970       22931       22932 AC   0.00000E+00
LA2970       22930       22931      0.12767E-08
CA2971       22936           0      0.49647E-14
RA2971       22936           0      0.41938E+09
RA2972       22935       22936      0.53870E-02
VA2972       22934       22935 AC   0.00000E+00
LA2972       22933       22934      0.12767E-08
CA2973       22937           0      0.50472E-14
RA2973       22937           0      0.41938E+09
CA2974       22940           0      0.94876E-15
RA2974       22940           0      0.41938E+09
RA2975       22939       22940      0.53870E-02
VA2975       22938       22939 AC   0.00000E+00
LA2975       22937       22938      0.12767E-08
CA2976       22943           0      0.94876E-15
RA2976       22943           0      0.41938E+09
RA2977       22942       22943      0.53870E-02
VA2977       22941       22942 AC   0.00000E+00
LA2977       22940       22941      0.12767E-08
CA2978       22946           0      0.94876E-15
RA2978       22946           0      0.41938E+09
RA2979       22945       22946      0.53870E-02
VA2979       22944       22945 AC   0.00000E+00
LA2979       22943       22944      0.12767E-08
CA2980       22949           0      0.94876E-15
RA2980       22949           0      0.41938E+09
RA2981       22948       22949      0.53870E-02
VA2981       22947       22948 AC   0.00000E+00
LA2981       22946       22947      0.12767E-08
CA2982       22952           0      0.94876E-15
RA2982       22952           0      0.41938E+09
RA2983       22951       22952      0.53870E-02
VA2983       22950       22951 AC   0.00000E+00
LA2983       22949       22950      0.12767E-08
CA2984       22955           0      0.94876E-15
RA2984       22955           0      0.41938E+09
RA2985       22954       22955      0.53870E-02
VA2985       22953       22954 AC   0.00000E+00
LA2985       22952       22953      0.12767E-08
CA2986       22958           0      0.94876E-15
RA2986       22958           0      0.41938E+09
RA2987       22957       22958      0.53870E-02
VA2987       22956       22957 AC   0.00000E+00
LA2987       22955       22956      0.12767E-08
CA2988       22961           0      0.94876E-15
RA2988       22961           0      0.41938E+09
RA2989       22960       22961      0.53870E-02
VA2989       22959       22960 AC   0.00000E+00
LA2989       22958       22959      0.12767E-08
CA2990       22964           0      0.94876E-15
RA2990       22964           0      0.41938E+09
RA2991       22963       22964      0.53870E-02
VA2991       22962       22963 AC   0.00000E+00
LA2991       22961       22962      0.12767E-08
CA2992       22967           0      0.50472E-14
RA2992       22967           0      0.41938E+09
RA2993       22966       22967      0.53870E-02
VA2993       22965       22966 AC   0.00000E+00
LA2993       22964       22965      0.12767E-08
CA2994       22968           0      0.15566E-14
RA2994       22968           0      0.41938E+09
CA2995       22971           0      0.94876E-15
RA2995       22971           0      0.41938E+09
RA2996       22970       22971      0.53870E-02
VA2996       22969       22970 AC   0.00000E+00
LA2996       22968       22969      0.12767E-08
CA2997       22974           0      0.94876E-15
RA2997       22974           0      0.41938E+09
RA2998       22973       22974      0.53870E-02
VA2998       22972       22973 AC   0.00000E+00
LA2998       22971       22972      0.12767E-08
CA2999       22977           0      0.94876E-15
RA2999       22977           0      0.41938E+09
RA3000       22976       22977      0.53870E-02
VA3000       22975       22976 AC   0.00000E+00
LA3000       22974       22975      0.12767E-08
CA3001       22980           0      0.94876E-15
RA3001       22980           0      0.41938E+09
RA3002       22979       22980      0.53870E-02
VA3002       22978       22979 AC   0.00000E+00
LA3002       22977       22978      0.12767E-08
CA3003       22983           0      0.94876E-15
RA3003       22983           0      0.41938E+09
RA3004       22982       22983      0.53870E-02
VA3004       22981       22982 AC   0.00000E+00
LA3004       22980       22981      0.12767E-08
CA3005       22986           0      0.49647E-14
RA3005       22986           0      0.41938E+09
RA3006       22985       22986      0.53870E-02
VA3006       22984       22985 AC   0.00000E+00
LA3006       22983       22984      0.12767E-08
CA3007       22987           0      0.50472E-14
RA3007       22987           0      0.41938E+09
CA3008       22990           0      0.94876E-15
RA3008       22990           0      0.41938E+09
RA3009       22989       22990      0.53870E-02
VA3009       22988       22989 AC   0.00000E+00
LA3009       22987       22988      0.12767E-08
CA3010       22993           0      0.94876E-15
RA3010       22993           0      0.41938E+09
RA3011       22992       22993      0.53870E-02
VA3011       22991       22992 AC   0.00000E+00
LA3011       22990       22991      0.12767E-08
CA3012       22996           0      0.94876E-15
RA3012       22996           0      0.41938E+09
RA3013       22995       22996      0.53870E-02
VA3013       22994       22995 AC   0.00000E+00
LA3013       22993       22994      0.12767E-08
CA3014       22999           0      0.94876E-15
RA3014       22999           0      0.41938E+09
RA3015       22998       22999      0.53870E-02
VA3015       22997       22998 AC   0.00000E+00
LA3015       22996       22997      0.12767E-08
CA3016       23002           0      0.94876E-15
RA3016       23002           0      0.41938E+09
RA3017       23001       23002      0.53870E-02
VA3017       23000       23001 AC   0.00000E+00
LA3017       22999       23000      0.12767E-08
CA3018       23005           0      0.94876E-15
RA3018       23005           0      0.41938E+09
RA3019       23004       23005      0.53870E-02
VA3019       23003       23004 AC   0.00000E+00
LA3019       23002       23003      0.12767E-08
CA3020       23008           0      0.94876E-15
RA3020       23008           0      0.41938E+09
RA3021       23007       23008      0.53870E-02
VA3021       23006       23007 AC   0.00000E+00
LA3021       23005       23006      0.12767E-08
CA3022       23011           0      0.94876E-15
RA3022       23011           0      0.41938E+09
RA3023       23010       23011      0.53870E-02
VA3023       23009       23010 AC   0.00000E+00
LA3023       23008       23009      0.12767E-08
CA3024       23014           0      0.94876E-15
RA3024       23014           0      0.41938E+09
RA3025       23013       23014      0.53870E-02
VA3025       23012       23013 AC   0.00000E+00
LA3025       23011       23012      0.12767E-08
CA3026       23017           0      0.50472E-14
RA3026       23017           0      0.41938E+09
RA3027       23016       23017      0.53870E-02
VA3027       23015       23016 AC   0.00000E+00
LA3027       23014       23015      0.12767E-08
CA3028       23018           0      0.15566E-14
RA3028       23018           0      0.41938E+09
CA3029       23021           0      0.94876E-15
RA3029       23021           0      0.41938E+09
RA3030       23020       23021      0.53870E-02
VA3030       23019       23020 AC   0.00000E+00
LA3030       23018       23019      0.12767E-08
CA3031       23024           0      0.94876E-15
RA3031       23024           0      0.41938E+09
RA3032       23023       23024      0.53870E-02
VA3032       23022       23023 AC   0.00000E+00
LA3032       23021       23022      0.12767E-08
CA3033       23027           0      0.94876E-15
RA3033       23027           0      0.41938E+09
RA3034       23026       23027      0.53870E-02
VA3034       23025       23026 AC   0.00000E+00
LA3034       23024       23025      0.12767E-08
CA3035       23030           0      0.94876E-15
RA3035       23030           0      0.41938E+09
RA3036       23029       23030      0.53870E-02
VA3036       23028       23029 AC   0.00000E+00
LA3036       23027       23028      0.12767E-08
CA3037       23033           0      0.94876E-15
RA3037       23033           0      0.41938E+09
RA3038       23032       23033      0.53870E-02
VA3038       23031       23032 AC   0.00000E+00
LA3038       23030       23031      0.12767E-08
CA3039       23036           0      0.49647E-14
RA3039       23036           0      0.41938E+09
RA3040       23035       23036      0.53870E-02
VA3040       23034       23035 AC   0.00000E+00
LA3040       23033       23034      0.12767E-08
CA3041       23037           0      0.50472E-14
RA3041       23037           0      0.41938E+09
CA3042       23040           0      0.94876E-15
RA3042       23040           0      0.41938E+09
RA3043       23039       23040      0.53870E-02
VA3043       23038       23039 AC   0.00000E+00
LA3043       23037       23038      0.12767E-08
CA3044       23043           0      0.94876E-15
RA3044       23043           0      0.41938E+09
RA3045       23042       23043      0.53870E-02
VA3045       23041       23042 AC   0.00000E+00
LA3045       23040       23041      0.12767E-08
CA3046       23046           0      0.94876E-15
RA3046       23046           0      0.41938E+09
RA3047       23045       23046      0.53870E-02
VA3047       23044       23045 AC   0.00000E+00
LA3047       23043       23044      0.12767E-08
CA3048       23049           0      0.94876E-15
RA3048       23049           0      0.41938E+09
RA3049       23048       23049      0.53870E-02
VA3049       23047       23048 AC   0.00000E+00
LA3049       23046       23047      0.12767E-08
CA3050       23052           0      0.94876E-15
RA3050       23052           0      0.41938E+09
RA3051       23051       23052      0.53870E-02
VA3051       23050       23051 AC   0.00000E+00
LA3051       23049       23050      0.12767E-08
CA3052       23055           0      0.94876E-15
RA3052       23055           0      0.41938E+09
RA3053       23054       23055      0.53870E-02
VA3053       23053       23054 AC   0.00000E+00
LA3053       23052       23053      0.12767E-08
CA3054       23058           0      0.94876E-15
RA3054       23058           0      0.41938E+09
RA3055       23057       23058      0.53870E-02
VA3055       23056       23057 AC   0.00000E+00
LA3055       23055       23056      0.12767E-08
CA3056       23061           0      0.94876E-15
RA3056       23061           0      0.41938E+09
RA3057       23060       23061      0.53870E-02
VA3057       23059       23060 AC   0.00000E+00
LA3057       23058       23059      0.12767E-08
CA3058       23064           0      0.94876E-15
RA3058       23064           0      0.41938E+09
RA3059       23063       23064      0.53870E-02
VA3059       23062       23063 AC   0.00000E+00
LA3059       23061       23062      0.12767E-08
CA3060       23067           0      0.50472E-14
RA3060       23067           0      0.41938E+09
RA3061       23066       23067      0.53870E-02
VA3061       23065       23066 AC   0.00000E+00
LA3061       23064       23065      0.12767E-08
CA3062       23068           0      0.15566E-14
RA3062       23068           0      0.41938E+09
CA3063       23071           0      0.94876E-15
RA3063       23071           0      0.41938E+09
RA3064       23070       23071      0.53870E-02
VA3064       23069       23070 AC   0.00000E+00
LA3064       23068       23069      0.12767E-08
CA3065       23074           0      0.94876E-15
RA3065       23074           0      0.41938E+09
RA3066       23073       23074      0.53870E-02
VA3066       23072       23073 AC   0.00000E+00
LA3066       23071       23072      0.12767E-08
CA3067       23077           0      0.94876E-15
RA3067       23077           0      0.41938E+09
RA3068       23076       23077      0.53870E-02
VA3068       23075       23076 AC   0.00000E+00
LA3068       23074       23075      0.12767E-08
CA3069       23080           0      0.94876E-15
RA3069       23080           0      0.41938E+09
RA3070       23079       23080      0.53870E-02
VA3070       23078       23079 AC   0.00000E+00
LA3070       23077       23078      0.12767E-08
CA3071       23083           0      0.94876E-15
RA3071       23083           0      0.41938E+09
RA3072       23082       23083      0.53870E-02
VA3072       23081       23082 AC   0.00000E+00
LA3072       23080       23081      0.12767E-08
CA3073       23086           0      0.49647E-14
RA3073       23086           0      0.41938E+09
RA3074       23085       23086      0.53870E-02
VA3074       23084       23085 AC   0.00000E+00
LA3074       23083       23084      0.12767E-08
CA3075       23087           0      0.50472E-14
RA3075       23087           0      0.41938E+09
CA3076       23090           0      0.94876E-15
RA3076       23090           0      0.41938E+09
RA3077       23089       23090      0.53870E-02
VA3077       23088       23089 AC   0.00000E+00
LA3077       23087       23088      0.12767E-08
CA3078       23093           0      0.94876E-15
RA3078       23093           0      0.41938E+09
RA3079       23092       23093      0.53870E-02
VA3079       23091       23092 AC   0.00000E+00
LA3079       23090       23091      0.12767E-08
CA3080       23096           0      0.94876E-15
RA3080       23096           0      0.41938E+09
RA3081       23095       23096      0.53870E-02
VA3081       23094       23095 AC   0.00000E+00
LA3081       23093       23094      0.12767E-08
CA3082       23099           0      0.94876E-15
RA3082       23099           0      0.41938E+09
RA3083       23098       23099      0.53870E-02
VA3083       23097       23098 AC   0.00000E+00
LA3083       23096       23097      0.12767E-08
CA3084       23102           0      0.94876E-15
RA3084       23102           0      0.41938E+09
RA3085       23101       23102      0.53870E-02
VA3085       23100       23101 AC   0.00000E+00
LA3085       23099       23100      0.12767E-08
CA3086       23105           0      0.94876E-15
RA3086       23105           0      0.41938E+09
RA3087       23104       23105      0.53870E-02
VA3087       23103       23104 AC   0.00000E+00
LA3087       23102       23103      0.12767E-08
CA3088       23108           0      0.94876E-15
RA3088       23108           0      0.41938E+09
RA3089       23107       23108      0.53870E-02
VA3089       23106       23107 AC   0.00000E+00
LA3089       23105       23106      0.12767E-08
CA3090       23111           0      0.94876E-15
RA3090       23111           0      0.41938E+09
RA3091       23110       23111      0.53870E-02
VA3091       23109       23110 AC   0.00000E+00
LA3091       23108       23109      0.12767E-08
CA3092       23114           0      0.94876E-15
RA3092       23114           0      0.41938E+09
RA3093       23113       23114      0.53870E-02
VA3093       23112       23113 AC   0.00000E+00
LA3093       23111       23112      0.12767E-08
CA3094       23117           0      0.50472E-14
RA3094       23117           0      0.41938E+09
RA3095       23116       23117      0.53870E-02
VA3095       23115       23116 AC   0.00000E+00
LA3095       23114       23115      0.12767E-08
CA3096       23118           0      0.15566E-14
RA3096       23118           0      0.41938E+09
CA3097       23121           0      0.94876E-15
RA3097       23121           0      0.41938E+09
RA3098       23120       23121      0.53870E-02
VA3098       23119       23120 AC   0.00000E+00
LA3098       23118       23119      0.12767E-08
CA3099       23124           0      0.94876E-15
RA3099       23124           0      0.41938E+09
RA3100       23123       23124      0.53870E-02
VA3100       23122       23123 AC   0.00000E+00
LA3100       23121       23122      0.12767E-08
CA3101       23127           0      0.94876E-15
RA3101       23127           0      0.41938E+09
RA3102       23126       23127      0.53870E-02
VA3102       23125       23126 AC   0.00000E+00
LA3102       23124       23125      0.12767E-08
CA3103       23130           0      0.94876E-15
RA3103       23130           0      0.41938E+09
RA3104       23129       23130      0.53870E-02
VA3104       23128       23129 AC   0.00000E+00
LA3104       23127       23128      0.12767E-08
CA3105       23133           0      0.94876E-15
RA3105       23133           0      0.41938E+09
RA3106       23132       23133      0.53870E-02
VA3106       23131       23132 AC   0.00000E+00
LA3106       23130       23131      0.12767E-08
CA3107       23136           0      0.49647E-14
RA3107       23136           0      0.41938E+09
RA3108       23135       23136      0.53870E-02
VA3108       23134       23135 AC   0.00000E+00
LA3108       23133       23134      0.12767E-08
CA3109       23137           0      0.50472E-14
RA3109       23137           0      0.41938E+09
CA3110       23140           0      0.94876E-15
RA3110       23140           0      0.41938E+09
RA3111       23139       23140      0.53870E-02
VA3111       23138       23139 AC   0.00000E+00
LA3111       23137       23138      0.12767E-08
CA3112       23143           0      0.94876E-15
RA3112       23143           0      0.41938E+09
RA3113       23142       23143      0.53870E-02
VA3113       23141       23142 AC   0.00000E+00
LA3113       23140       23141      0.12767E-08
CA3114       23146           0      0.94876E-15
RA3114       23146           0      0.41938E+09
RA3115       23145       23146      0.53870E-02
VA3115       23144       23145 AC   0.00000E+00
LA3115       23143       23144      0.12767E-08
CA3116       23149           0      0.94876E-15
RA3116       23149           0      0.41938E+09
RA3117       23148       23149      0.53870E-02
VA3117       23147       23148 AC   0.00000E+00
LA3117       23146       23147      0.12767E-08
CA3118       23152           0      0.94876E-15
RA3118       23152           0      0.41938E+09
RA3119       23151       23152      0.53870E-02
VA3119       23150       23151 AC   0.00000E+00
LA3119       23149       23150      0.12767E-08
CA3120       23155           0      0.94876E-15
RA3120       23155           0      0.41938E+09
RA3121       23154       23155      0.53870E-02
VA3121       23153       23154 AC   0.00000E+00
LA3121       23152       23153      0.12767E-08
CA3122       23158           0      0.94876E-15
RA3122       23158           0      0.41938E+09
RA3123       23157       23158      0.53870E-02
VA3123       23156       23157 AC   0.00000E+00
LA3123       23155       23156      0.12767E-08
CA3124       23161           0      0.94876E-15
RA3124       23161           0      0.41938E+09
RA3125       23160       23161      0.53870E-02
VA3125       23159       23160 AC   0.00000E+00
LA3125       23158       23159      0.12767E-08
CA3126       23164           0      0.94876E-15
RA3126       23164           0      0.41938E+09
RA3127       23163       23164      0.53870E-02
VA3127       23162       23163 AC   0.00000E+00
LA3127       23161       23162      0.12767E-08
CA3128       23167           0      0.50472E-14
RA3128       23167           0      0.41938E+09
RA3129       23166       23167      0.53870E-02
VA3129       23165       23166 AC   0.00000E+00
LA3129       23164       23165      0.12767E-08
CA3130       23168           0      0.15566E-14
RA3130       23168           0      0.41938E+09
CA3131       23171           0      0.94876E-15
RA3131       23171           0      0.41938E+09
RA3132       23170       23171      0.53870E-02
VA3132       23169       23170 AC   0.00000E+00
LA3132       23168       23169      0.12767E-08
CA3133       23174           0      0.94876E-15
RA3133       23174           0      0.41938E+09
RA3134       23173       23174      0.53870E-02
VA3134       23172       23173 AC   0.00000E+00
LA3134       23171       23172      0.12767E-08
CA3135       23177           0      0.94876E-15
RA3135       23177           0      0.41938E+09
RA3136       23176       23177      0.53870E-02
VA3136       23175       23176 AC   0.00000E+00
LA3136       23174       23175      0.12767E-08
CA3137       23180           0      0.94876E-15
RA3137       23180           0      0.41938E+09
RA3138       23179       23180      0.53870E-02
VA3138       23178       23179 AC   0.00000E+00
LA3138       23177       23178      0.12767E-08
CA3139       23183           0      0.94876E-15
RA3139       23183           0      0.41938E+09
RA3140       23182       23183      0.53870E-02
VA3140       23181       23182 AC   0.00000E+00
LA3140       23180       23181      0.12767E-08
CA3141       23186           0      0.49647E-14
RA3141       23186           0      0.41938E+09
RA3142       23185       23186      0.53870E-02
VA3142       23184       23185 AC   0.00000E+00
LA3142       23183       23184      0.12767E-08
CA3143       23187           0      0.50472E-14
RA3143       23187           0      0.41938E+09
CA3144       23190           0      0.94876E-15
RA3144       23190           0      0.41938E+09
RA3145       23189       23190      0.53870E-02
VA3145       23188       23189 AC   0.00000E+00
LA3145       23187       23188      0.12767E-08
CA3146       23193           0      0.94876E-15
RA3146       23193           0      0.41938E+09
RA3147       23192       23193      0.53870E-02
VA3147       23191       23192 AC   0.00000E+00
LA3147       23190       23191      0.12767E-08
CA3148       23196           0      0.94876E-15
RA3148       23196           0      0.41938E+09
RA3149       23195       23196      0.53870E-02
VA3149       23194       23195 AC   0.00000E+00
LA3149       23193       23194      0.12767E-08
CA3150       23199           0      0.94876E-15
RA3150       23199           0      0.41938E+09
RA3151       23198       23199      0.53870E-02
VA3151       23197       23198 AC   0.00000E+00
LA3151       23196       23197      0.12767E-08
CA3152       23202           0      0.94876E-15
RA3152       23202           0      0.41938E+09
RA3153       23201       23202      0.53870E-02
VA3153       23200       23201 AC   0.00000E+00
LA3153       23199       23200      0.12767E-08
CA3154       23205           0      0.94876E-15
RA3154       23205           0      0.41938E+09
RA3155       23204       23205      0.53870E-02
VA3155       23203       23204 AC   0.00000E+00
LA3155       23202       23203      0.12767E-08
CA3156       23208           0      0.94876E-15
RA3156       23208           0      0.41938E+09
RA3157       23207       23208      0.53870E-02
VA3157       23206       23207 AC   0.00000E+00
LA3157       23205       23206      0.12767E-08
CA3158       23211           0      0.94876E-15
RA3158       23211           0      0.41938E+09
RA3159       23210       23211      0.53870E-02
VA3159       23209       23210 AC   0.00000E+00
LA3159       23208       23209      0.12767E-08
CA3160       23214           0      0.94876E-15
RA3160       23214           0      0.41938E+09
RA3161       23213       23214      0.53870E-02
VA3161       23212       23213 AC   0.00000E+00
LA3161       23211       23212      0.12767E-08
CA3162       23217           0      0.50472E-14
RA3162       23217           0      0.41938E+09
RA3163       23216       23217      0.53870E-02
VA3163       23215       23216 AC   0.00000E+00
LA3163       23214       23215      0.12767E-08
CA3164       23218           0      0.15566E-14
RA3164       23218           0      0.41938E+09
CA3165       23221           0      0.94876E-15
RA3165       23221           0      0.41938E+09
RA3166       23220       23221      0.53870E-02
VA3166       23219       23220 AC   0.00000E+00
LA3166       23218       23219      0.12767E-08
CA3167       23224           0      0.94876E-15
RA3167       23224           0      0.41938E+09
RA3168       23223       23224      0.53870E-02
VA3168       23222       23223 AC   0.00000E+00
LA3168       23221       23222      0.12767E-08
CA3169       23227           0      0.94876E-15
RA3169       23227           0      0.41938E+09
RA3170       23226       23227      0.53870E-02
VA3170       23225       23226 AC   0.00000E+00
LA3170       23224       23225      0.12767E-08
CA3171       23230           0      0.94876E-15
RA3171       23230           0      0.41938E+09
RA3172       23229       23230      0.53870E-02
VA3172       23228       23229 AC   0.00000E+00
LA3172       23227       23228      0.12767E-08
CA3173       23233           0      0.94876E-15
RA3173       23233           0      0.41938E+09
RA3174       23232       23233      0.53870E-02
VA3174       23231       23232 AC   0.00000E+00
LA3174       23230       23231      0.12767E-08
CA3175       23236           0      0.49647E-14
RA3175       23236           0      0.41938E+09
RA3176       23235       23236      0.53870E-02
VA3176       23234       23235 AC   0.00000E+00
LA3176       23233       23234      0.12767E-08
CA3177       23237           0      0.50472E-14
RA3177       23237           0      0.41938E+09
CA3178       23240           0      0.94876E-15
RA3178       23240           0      0.41938E+09
RA3179       23239       23240      0.53870E-02
VA3179       23238       23239 AC   0.00000E+00
LA3179       23237       23238      0.12767E-08
CA3180       23243           0      0.94876E-15
RA3180       23243           0      0.41938E+09
RA3181       23242       23243      0.53870E-02
VA3181       23241       23242 AC   0.00000E+00
LA3181       23240       23241      0.12767E-08
CA3182       23246           0      0.94876E-15
RA3182       23246           0      0.41938E+09
RA3183       23245       23246      0.53870E-02
VA3183       23244       23245 AC   0.00000E+00
LA3183       23243       23244      0.12767E-08
CA3184       23249           0      0.94876E-15
RA3184       23249           0      0.41938E+09
RA3185       23248       23249      0.53870E-02
VA3185       23247       23248 AC   0.00000E+00
LA3185       23246       23247      0.12767E-08
CA3186       23252           0      0.94876E-15
RA3186       23252           0      0.41938E+09
RA3187       23251       23252      0.53870E-02
VA3187       23250       23251 AC   0.00000E+00
LA3187       23249       23250      0.12767E-08
CA3188       23255           0      0.94876E-15
RA3188       23255           0      0.41938E+09
RA3189       23254       23255      0.53870E-02
VA3189       23253       23254 AC   0.00000E+00
LA3189       23252       23253      0.12767E-08
CA3190       23258           0      0.94876E-15
RA3190       23258           0      0.41938E+09
RA3191       23257       23258      0.53870E-02
VA3191       23256       23257 AC   0.00000E+00
LA3191       23255       23256      0.12767E-08
CA3192       23261           0      0.94876E-15
RA3192       23261           0      0.41938E+09
RA3193       23260       23261      0.53870E-02
VA3193       23259       23260 AC   0.00000E+00
LA3193       23258       23259      0.12767E-08
CA3194       23264           0      0.94876E-15
RA3194       23264           0      0.41938E+09
RA3195       23263       23264      0.53870E-02
VA3195       23262       23263 AC   0.00000E+00
LA3195       23261       23262      0.12767E-08
CA3196       23267           0      0.50472E-14
RA3196       23267           0      0.41938E+09
RA3197       23266       23267      0.53870E-02
VA3197       23265       23266 AC   0.00000E+00
LA3197       23264       23265      0.12767E-08
CA3198       23268           0      0.15566E-14
RA3198       23268           0      0.41938E+09
CA3199       23271           0      0.94876E-15
RA3199       23271           0      0.41938E+09
RA3200       23270       23271      0.53870E-02
VA3200       23269       23270 AC   0.00000E+00
LA3200       23268       23269      0.12767E-08
CA3201       23274           0      0.94876E-15
RA3201       23274           0      0.41938E+09
RA3202       23273       23274      0.53870E-02
VA3202       23272       23273 AC   0.00000E+00
LA3202       23271       23272      0.12767E-08
CA3203       23277           0      0.94876E-15
RA3203       23277           0      0.41938E+09
RA3204       23276       23277      0.53870E-02
VA3204       23275       23276 AC   0.00000E+00
LA3204       23274       23275      0.12767E-08
CA3205       23280           0      0.94876E-15
RA3205       23280           0      0.41938E+09
RA3206       23279       23280      0.53870E-02
VA3206       23278       23279 AC   0.00000E+00
LA3206       23277       23278      0.12767E-08
CA3207       23283           0      0.94876E-15
RA3207       23283           0      0.41938E+09
RA3208       23282       23283      0.53870E-02
VA3208       23281       23282 AC   0.00000E+00
LA3208       23280       23281      0.12767E-08
CA3209       23286           0      0.49647E-14
RA3209       23286           0      0.41938E+09
RA3210       23285       23286      0.53870E-02
VA3210       23284       23285 AC   0.00000E+00
LA3210       23283       23284      0.12767E-08
CA3211       23287           0      0.50472E-14
RA3211       23287           0      0.41938E+09
CA3212       23290           0      0.94876E-15
RA3212       23290           0      0.41938E+09
RA3213       23289       23290      0.53870E-02
VA3213       23288       23289 AC   0.00000E+00
LA3213       23287       23288      0.12767E-08
CA3214       23293           0      0.94876E-15
RA3214       23293           0      0.41938E+09
RA3215       23292       23293      0.53870E-02
VA3215       23291       23292 AC   0.00000E+00
LA3215       23290       23291      0.12767E-08
CA3216       23296           0      0.94876E-15
RA3216       23296           0      0.41938E+09
RA3217       23295       23296      0.53870E-02
VA3217       23294       23295 AC   0.00000E+00
LA3217       23293       23294      0.12767E-08
CA3218       23299           0      0.94876E-15
RA3218       23299           0      0.41938E+09
RA3219       23298       23299      0.53870E-02
VA3219       23297       23298 AC   0.00000E+00
LA3219       23296       23297      0.12767E-08
CA3220       23302           0      0.94876E-15
RA3220       23302           0      0.41938E+09
RA3221       23301       23302      0.53870E-02
VA3221       23300       23301 AC   0.00000E+00
LA3221       23299       23300      0.12767E-08
CA3222       23305           0      0.94876E-15
RA3222       23305           0      0.41938E+09
RA3223       23304       23305      0.53870E-02
VA3223       23303       23304 AC   0.00000E+00
LA3223       23302       23303      0.12767E-08
CA3224       23308           0      0.94876E-15
RA3224       23308           0      0.41938E+09
RA3225       23307       23308      0.53870E-02
VA3225       23306       23307 AC   0.00000E+00
LA3225       23305       23306      0.12767E-08
CA3226       23311           0      0.94876E-15
RA3226       23311           0      0.41938E+09
RA3227       23310       23311      0.53870E-02
VA3227       23309       23310 AC   0.00000E+00
LA3227       23308       23309      0.12767E-08
CA3228       23314           0      0.94876E-15
RA3228       23314           0      0.41938E+09
RA3229       23313       23314      0.53870E-02
VA3229       23312       23313 AC   0.00000E+00
LA3229       23311       23312      0.12767E-08
CA3230       23317           0      0.50472E-14
RA3230       23317           0      0.41938E+09
RA3231       23316       23317      0.53870E-02
VA3231       23315       23316 AC   0.00000E+00
LA3231       23314       23315      0.12767E-08
CA3232       23318           0      0.15566E-14
RA3232       23318           0      0.41938E+09
CA3233       23321           0      0.94876E-15
RA3233       23321           0      0.41938E+09
RA3234       23320       23321      0.53870E-02
VA3234       23319       23320 AC   0.00000E+00
LA3234       23318       23319      0.12767E-08
CA3235       23324           0      0.94876E-15
RA3235       23324           0      0.41938E+09
RA3236       23323       23324      0.53870E-02
VA3236       23322       23323 AC   0.00000E+00
LA3236       23321       23322      0.12767E-08
CA3237       23327           0      0.94876E-15
RA3237       23327           0      0.41938E+09
RA3238       23326       23327      0.53870E-02
VA3238       23325       23326 AC   0.00000E+00
LA3238       23324       23325      0.12767E-08
CA3239       23330           0      0.94876E-15
RA3239       23330           0      0.41938E+09
RA3240       23329       23330      0.53870E-02
VA3240       23328       23329 AC   0.00000E+00
LA3240       23327       23328      0.12767E-08
CA3241       23333           0      0.94876E-15
RA3241       23333           0      0.41938E+09
RA3242       23332       23333      0.53870E-02
VA3242       23331       23332 AC   0.00000E+00
LA3242       23330       23331      0.12767E-08
CA3243       23336           0      0.49647E-14
RA3243       23336           0      0.41938E+09
RA3244       23335       23336      0.53870E-02
VA3244       23334       23335 AC   0.00000E+00
LA3244       23333       23334      0.12767E-08
CA3245       23337           0      0.50472E-14
RA3245       23337           0      0.41938E+09
CA3246       23340           0      0.94876E-15
RA3246       23340           0      0.41938E+09
RA3247       23339       23340      0.53870E-02
VA3247       23338       23339 AC   0.00000E+00
LA3247       23337       23338      0.12767E-08
CA3248       23343           0      0.94876E-15
RA3248       23343           0      0.41938E+09
RA3249       23342       23343      0.53870E-02
VA3249       23341       23342 AC   0.00000E+00
LA3249       23340       23341      0.12767E-08
CA3250       23346           0      0.94876E-15
RA3250       23346           0      0.41938E+09
RA3251       23345       23346      0.53870E-02
VA3251       23344       23345 AC   0.00000E+00
LA3251       23343       23344      0.12767E-08
CA3252       23349           0      0.94876E-15
RA3252       23349           0      0.41938E+09
RA3253       23348       23349      0.53870E-02
VA3253       23347       23348 AC   0.00000E+00
LA3253       23346       23347      0.12767E-08
CA3254       23352           0      0.94876E-15
RA3254       23352           0      0.41938E+09
RA3255       23351       23352      0.53870E-02
VA3255       23350       23351 AC   0.00000E+00
LA3255       23349       23350      0.12767E-08
CA3256       23355           0      0.94876E-15
RA3256       23355           0      0.41938E+09
RA3257       23354       23355      0.53870E-02
VA3257       23353       23354 AC   0.00000E+00
LA3257       23352       23353      0.12767E-08
CA3258       23358           0      0.94876E-15
RA3258       23358           0      0.41938E+09
RA3259       23357       23358      0.53870E-02
VA3259       23356       23357 AC   0.00000E+00
LA3259       23355       23356      0.12767E-08
CA3260       23361           0      0.94876E-15
RA3260       23361           0      0.41938E+09
RA3261       23360       23361      0.53870E-02
VA3261       23359       23360 AC   0.00000E+00
LA3261       23358       23359      0.12767E-08
CA3262       23364           0      0.94876E-15
RA3262       23364           0      0.41938E+09
RA3263       23363       23364      0.53870E-02
VA3263       23362       23363 AC   0.00000E+00
LA3263       23361       23362      0.12767E-08
CA3264       23367           0      0.50472E-14
RA3264       23367           0      0.41938E+09
RA3265       23366       23367      0.53870E-02
VA3265       23365       23366 AC   0.00000E+00
LA3265       23364       23365      0.12767E-08
CA3266       23368           0      0.15566E-14
RA3266       23368           0      0.41938E+09
CA3267       23371           0      0.94876E-15
RA3267       23371           0      0.41938E+09
RA3268       23370       23371      0.53870E-02
VA3268       23369       23370 AC   0.00000E+00
LA3268       23368       23369      0.12767E-08
CA3269       23374           0      0.94876E-15
RA3269       23374           0      0.41938E+09
RA3270       23373       23374      0.53870E-02
VA3270       23372       23373 AC   0.00000E+00
LA3270       23371       23372      0.12767E-08
CA3271       23377           0      0.94876E-15
RA3271       23377           0      0.41938E+09
RA3272       23376       23377      0.53870E-02
VA3272       23375       23376 AC   0.00000E+00
LA3272       23374       23375      0.12767E-08
CA3273       23380           0      0.94876E-15
RA3273       23380           0      0.41938E+09
RA3274       23379       23380      0.53870E-02
VA3274       23378       23379 AC   0.00000E+00
LA3274       23377       23378      0.12767E-08
CA3275       23383           0      0.94876E-15
RA3275       23383           0      0.41938E+09
RA3276       23382       23383      0.53870E-02
VA3276       23381       23382 AC   0.00000E+00
LA3276       23380       23381      0.12767E-08
CA3277       23386           0      0.49647E-14
RA3277       23386           0      0.41938E+09
RA3278       23385       23386      0.53870E-02
VA3278       23384       23385 AC   0.00000E+00
LA3278       23383       23384      0.12767E-08
CA3279       23387           0      0.50472E-14
RA3279       23387           0      0.41938E+09
CA3280       23390           0      0.94876E-15
RA3280       23390           0      0.41938E+09
RA3281       23389       23390      0.53870E-02
VA3281       23388       23389 AC   0.00000E+00
LA3281       23387       23388      0.12767E-08
CA3282       23393           0      0.94876E-15
RA3282       23393           0      0.41938E+09
RA3283       23392       23393      0.53870E-02
VA3283       23391       23392 AC   0.00000E+00
LA3283       23390       23391      0.12767E-08
CA3284       23396           0      0.94876E-15
RA3284       23396           0      0.41938E+09
RA3285       23395       23396      0.53870E-02
VA3285       23394       23395 AC   0.00000E+00
LA3285       23393       23394      0.12767E-08
CA3286       23399           0      0.94876E-15
RA3286       23399           0      0.41938E+09
RA3287       23398       23399      0.53870E-02
VA3287       23397       23398 AC   0.00000E+00
LA3287       23396       23397      0.12767E-08
CA3288       23402           0      0.94876E-15
RA3288       23402           0      0.41938E+09
RA3289       23401       23402      0.53870E-02
VA3289       23400       23401 AC   0.00000E+00
LA3289       23399       23400      0.12767E-08
CA3290       23405           0      0.94876E-15
RA3290       23405           0      0.41938E+09
RA3291       23404       23405      0.53870E-02
VA3291       23403       23404 AC   0.00000E+00
LA3291       23402       23403      0.12767E-08
CA3292       23408           0      0.94876E-15
RA3292       23408           0      0.41938E+09
RA3293       23407       23408      0.53870E-02
VA3293       23406       23407 AC   0.00000E+00
LA3293       23405       23406      0.12767E-08
CA3294       23411           0      0.94876E-15
RA3294       23411           0      0.41938E+09
RA3295       23410       23411      0.53870E-02
VA3295       23409       23410 AC   0.00000E+00
LA3295       23408       23409      0.12767E-08
CA3296       23414           0      0.94876E-15
RA3296       23414           0      0.41938E+09
RA3297       23413       23414      0.53870E-02
VA3297       23412       23413 AC   0.00000E+00
LA3297       23411       23412      0.12767E-08
CA3298       23417           0      0.50472E-14
RA3298       23417           0      0.41938E+09
RA3299       23416       23417      0.53870E-02
VA3299       23415       23416 AC   0.00000E+00
LA3299       23414       23415      0.12767E-08
CA3300       23418           0      0.15566E-14
RA3300       23418           0      0.41938E+09
CA3301       23421           0      0.94876E-15
RA3301       23421           0      0.41938E+09
RA3302       23420       23421      0.53870E-02
VA3302       23419       23420 AC   0.00000E+00
LA3302       23418       23419      0.12767E-08
CA3303       23424           0      0.94876E-15
RA3303       23424           0      0.41938E+09
RA3304       23423       23424      0.53870E-02
VA3304       23422       23423 AC   0.00000E+00
LA3304       23421       23422      0.12767E-08
CA3305       23427           0      0.94876E-15
RA3305       23427           0      0.41938E+09
RA3306       23426       23427      0.53870E-02
VA3306       23425       23426 AC   0.00000E+00
LA3306       23424       23425      0.12767E-08
CA3307       23430           0      0.94876E-15
RA3307       23430           0      0.41938E+09
RA3308       23429       23430      0.53870E-02
VA3308       23428       23429 AC   0.00000E+00
LA3308       23427       23428      0.12767E-08
CA3309       23433           0      0.94876E-15
RA3309       23433           0      0.41938E+09
RA3310       23432       23433      0.53870E-02
VA3310       23431       23432 AC   0.00000E+00
LA3310       23430       23431      0.12767E-08
CA3311       23436           0      0.49647E-14
RA3311       23436           0      0.41938E+09
RA3312       23435       23436      0.53870E-02
VA3312       23434       23435 AC   0.00000E+00
LA3312       23433       23434      0.12767E-08
CA3313       23437           0      0.50472E-14
RA3313       23437           0      0.41938E+09
CA3314       23440           0      0.94876E-15
RA3314       23440           0      0.41938E+09
RA3315       23439       23440      0.53870E-02
VA3315       23438       23439 AC   0.00000E+00
LA3315       23437       23438      0.12767E-08
CA3316       23443           0      0.94876E-15
RA3316       23443           0      0.41938E+09
RA3317       23442       23443      0.53870E-02
VA3317       23441       23442 AC   0.00000E+00
LA3317       23440       23441      0.12767E-08
CA3318       23446           0      0.94876E-15
RA3318       23446           0      0.41938E+09
RA3319       23445       23446      0.53870E-02
VA3319       23444       23445 AC   0.00000E+00
LA3319       23443       23444      0.12767E-08
CA3320       23449           0      0.94876E-15
RA3320       23449           0      0.41938E+09
RA3321       23448       23449      0.53870E-02
VA3321       23447       23448 AC   0.00000E+00
LA3321       23446       23447      0.12767E-08
CA3322       23452           0      0.94876E-15
RA3322       23452           0      0.41938E+09
RA3323       23451       23452      0.53870E-02
VA3323       23450       23451 AC   0.00000E+00
LA3323       23449       23450      0.12767E-08
CA3324       23455           0      0.94876E-15
RA3324       23455           0      0.41938E+09
RA3325       23454       23455      0.53870E-02
VA3325       23453       23454 AC   0.00000E+00
LA3325       23452       23453      0.12767E-08
CA3326       23458           0      0.94876E-15
RA3326       23458           0      0.41938E+09
RA3327       23457       23458      0.53870E-02
VA3327       23456       23457 AC   0.00000E+00
LA3327       23455       23456      0.12767E-08
CA3328       23461           0      0.94876E-15
RA3328       23461           0      0.41938E+09
RA3329       23460       23461      0.53870E-02
VA3329       23459       23460 AC   0.00000E+00
LA3329       23458       23459      0.12767E-08
CA3330       23464           0      0.94876E-15
RA3330       23464           0      0.41938E+09
RA3331       23463       23464      0.53870E-02
VA3331       23462       23463 AC   0.00000E+00
LA3331       23461       23462      0.12767E-08
CA3332       23467           0      0.50472E-14
RA3332       23467           0      0.41938E+09
RA3333       23466       23467      0.53870E-02
VA3333       23465       23466 AC   0.00000E+00
LA3333       23464       23465      0.12767E-08
CA3334       23468           0      0.15566E-14
RA3334       23468           0      0.41938E+09
CA3335       23471           0      0.94876E-15
RA3335       23471           0      0.41938E+09
RA3336       23470       23471      0.53870E-02
VA3336       23469       23470 AC   0.00000E+00
LA3336       23468       23469      0.12767E-08
CA3337       23474           0      0.94876E-15
RA3337       23474           0      0.41938E+09
RA3338       23473       23474      0.53870E-02
VA3338       23472       23473 AC   0.00000E+00
LA3338       23471       23472      0.12767E-08
CA3339       23477           0      0.94876E-15
RA3339       23477           0      0.41938E+09
RA3340       23476       23477      0.53870E-02
VA3340       23475       23476 AC   0.00000E+00
LA3340       23474       23475      0.12767E-08
CA3341       23480           0      0.94876E-15
RA3341       23480           0      0.41938E+09
RA3342       23479       23480      0.53870E-02
VA3342       23478       23479 AC   0.00000E+00
LA3342       23477       23478      0.12767E-08
CA3343       23483           0      0.94876E-15
RA3343       23483           0      0.41938E+09
RA3344       23482       23483      0.53870E-02
VA3344       23481       23482 AC   0.00000E+00
LA3344       23480       23481      0.12767E-08
CA3345       23486           0      0.49647E-14
RA3345       23486           0      0.41938E+09
RA3346       23485       23486      0.53870E-02
VA3346       23484       23485 AC   0.00000E+00
LA3346       23483       23484      0.12767E-08
CA3347       23487           0      0.50472E-14
RA3347       23487           0      0.41938E+09
CA3348       23490           0      0.94876E-15
RA3348       23490           0      0.41938E+09
RA3349       23489       23490      0.53870E-02
VA3349       23488       23489 AC   0.00000E+00
LA3349       23487       23488      0.12767E-08
CA3350       23493           0      0.94876E-15
RA3350       23493           0      0.41938E+09
RA3351       23492       23493      0.53870E-02
VA3351       23491       23492 AC   0.00000E+00
LA3351       23490       23491      0.12767E-08
CA3352       23496           0      0.94876E-15
RA3352       23496           0      0.41938E+09
RA3353       23495       23496      0.53870E-02
VA3353       23494       23495 AC   0.00000E+00
LA3353       23493       23494      0.12767E-08
CA3354       23499           0      0.94876E-15
RA3354       23499           0      0.41938E+09
RA3355       23498       23499      0.53870E-02
VA3355       23497       23498 AC   0.00000E+00
LA3355       23496       23497      0.12767E-08
CA3356       23502           0      0.94876E-15
RA3356       23502           0      0.41938E+09
RA3357       23501       23502      0.53870E-02
VA3357       23500       23501 AC   0.00000E+00
LA3357       23499       23500      0.12767E-08
CA3358       23505           0      0.94876E-15
RA3358       23505           0      0.41938E+09
RA3359       23504       23505      0.53870E-02
VA3359       23503       23504 AC   0.00000E+00
LA3359       23502       23503      0.12767E-08
CA3360       23508           0      0.94876E-15
RA3360       23508           0      0.41938E+09
RA3361       23507       23508      0.53870E-02
VA3361       23506       23507 AC   0.00000E+00
LA3361       23505       23506      0.12767E-08
CA3362       23511           0      0.94876E-15
RA3362       23511           0      0.41938E+09
RA3363       23510       23511      0.53870E-02
VA3363       23509       23510 AC   0.00000E+00
LA3363       23508       23509      0.12767E-08
CA3364       23514           0      0.94876E-15
RA3364       23514           0      0.41938E+09
RA3365       23513       23514      0.53870E-02
VA3365       23512       23513 AC   0.00000E+00
LA3365       23511       23512      0.12767E-08
CA3366       23517           0      0.50472E-14
RA3366       23517           0      0.41938E+09
RA3367       23516       23517      0.53870E-02
VA3367       23515       23516 AC   0.00000E+00
LA3367       23514       23515      0.12767E-08
CA3368       23518           0      0.15566E-14
RA3368       23518           0      0.41938E+09
CA3369       23521           0      0.94876E-15
RA3369       23521           0      0.41938E+09
RA3370       23520       23521      0.53870E-02
VA3370       23519       23520 AC   0.00000E+00
LA3370       23518       23519      0.12767E-08
CA3371       23524           0      0.94876E-15
RA3371       23524           0      0.41938E+09
RA3372       23523       23524      0.53870E-02
VA3372       23522       23523 AC   0.00000E+00
LA3372       23521       23522      0.12767E-08
CA3373       23527           0      0.94876E-15
RA3373       23527           0      0.41938E+09
RA3374       23526       23527      0.53870E-02
VA3374       23525       23526 AC   0.00000E+00
LA3374       23524       23525      0.12767E-08
CA3375       23530           0      0.94876E-15
RA3375       23530           0      0.41938E+09
RA3376       23529       23530      0.53870E-02
VA3376       23528       23529 AC   0.00000E+00
LA3376       23527       23528      0.12767E-08
CA3377       23533           0      0.94876E-15
RA3377       23533           0      0.41938E+09
RA3378       23532       23533      0.53870E-02
VA3378       23531       23532 AC   0.00000E+00
LA3378       23530       23531      0.12767E-08
CA3379       23536           0      0.49647E-14
RA3379       23536           0      0.41938E+09
RA3380       23535       23536      0.53870E-02
VA3380       23534       23535 AC   0.00000E+00
LA3380       23533       23534      0.12767E-08
CA3381       23537           0      0.50472E-14
RA3381       23537           0      0.41938E+09
CA3382       23540           0      0.94876E-15
RA3382       23540           0      0.41938E+09
RA3383       23539       23540      0.53870E-02
VA3383       23538       23539 AC   0.00000E+00
LA3383       23537       23538      0.12767E-08
CA3384       23543           0      0.94876E-15
RA3384       23543           0      0.41938E+09
RA3385       23542       23543      0.53870E-02
VA3385       23541       23542 AC   0.00000E+00
LA3385       23540       23541      0.12767E-08
CA3386       23546           0      0.94876E-15
RA3386       23546           0      0.41938E+09
RA3387       23545       23546      0.53870E-02
VA3387       23544       23545 AC   0.00000E+00
LA3387       23543       23544      0.12767E-08
CA3388       23549           0      0.94876E-15
RA3388       23549           0      0.41938E+09
RA3389       23548       23549      0.53870E-02
VA3389       23547       23548 AC   0.00000E+00
LA3389       23546       23547      0.12767E-08
CA3390       23552           0      0.94876E-15
RA3390       23552           0      0.41938E+09
RA3391       23551       23552      0.53870E-02
VA3391       23550       23551 AC   0.00000E+00
LA3391       23549       23550      0.12767E-08
CA3392       23555           0      0.94876E-15
RA3392       23555           0      0.41938E+09
RA3393       23554       23555      0.53870E-02
VA3393       23553       23554 AC   0.00000E+00
LA3393       23552       23553      0.12767E-08
CA3394       23558           0      0.94876E-15
RA3394       23558           0      0.41938E+09
RA3395       23557       23558      0.53870E-02
VA3395       23556       23557 AC   0.00000E+00
LA3395       23555       23556      0.12767E-08
CA3396       23561           0      0.94876E-15
RA3396       23561           0      0.41938E+09
RA3397       23560       23561      0.53870E-02
VA3397       23559       23560 AC   0.00000E+00
LA3397       23558       23559      0.12767E-08
CA3398       23564           0      0.94876E-15
RA3398       23564           0      0.41938E+09
RA3399       23563       23564      0.53870E-02
VA3399       23562       23563 AC   0.00000E+00
LA3399       23561       23562      0.12767E-08
CA3400       23567           0      0.50472E-14
RA3400       23567           0      0.41938E+09
RA3401       23566       23567      0.53870E-02
VA3401       23565       23566 AC   0.00000E+00
LA3401       23564       23565      0.12767E-08
CA3402       23568           0      0.33853E-14
RA3402       23568           0      0.41938E+09
CA3403       23571           0      0.52141E-14
RA3403       23571           0      0.41938E+09
RA3404       23570       23571      0.53870E-02
VA3404       23569       23570 AC   0.00000E+00
LA3404       23568       23569      0.11642E-09
CA3405       23574           0      0.52141E-14
RA3405       23574           0      0.41938E+09
RA3406       23573       23574      0.53870E-02
VA3406       23572       23573 AC   0.00000E+00
LA3406       23571       23572      0.11642E-09
CA3407       23577           0      0.52141E-14
RA3407       23577           0      0.41938E+09
RA3408       23576       23577      0.53870E-02
VA3408       23575       23576 AC   0.00000E+00
LA3408       23574       23575      0.11642E-09
CA3409       23580           0      0.52141E-14
RA3409       23580           0      0.41938E+09
RA3410       23579       23580      0.53870E-02
VA3410       23578       23579 AC   0.00000E+00
LA3410       23577       23578      0.11642E-09
CA3411       23583           0      0.52141E-14
RA3411       23583           0      0.41938E+09
RA3412       23582       23583      0.53870E-02
VA3412       23581       23582 AC   0.00000E+00
LA3412       23580       23581      0.11642E-09
CA3413       23586           0      0.50894E-14
RA3413       23586           0      0.41938E+09
RA3414       23585       23586      0.53870E-02
VA3414       23584       23585 AC   0.00000E+00
LA3414       23583       23584      0.11642E-09
CA3415       23587           0      0.50472E-14
RA3415       23587           0      0.41938E+09
CA3416       23590           0      0.94876E-15
RA3416       23590           0      0.41938E+09
RA3417       23589       23590      0.53870E-02
VA3417       23588       23589 AC   0.00000E+00
LA3417       23587       23588      0.12767E-08
CA3418       23593           0      0.94876E-15
RA3418       23593           0      0.41938E+09
RA3419       23592       23593      0.53870E-02
VA3419       23591       23592 AC   0.00000E+00
LA3419       23590       23591      0.12767E-08
CA3420       23596           0      0.94876E-15
RA3420       23596           0      0.41938E+09
RA3421       23595       23596      0.53870E-02
VA3421       23594       23595 AC   0.00000E+00
LA3421       23593       23594      0.12767E-08
CA3422       23599           0      0.94876E-15
RA3422       23599           0      0.41938E+09
RA3423       23598       23599      0.53870E-02
VA3423       23597       23598 AC   0.00000E+00
LA3423       23596       23597      0.12767E-08
CA3424       23602           0      0.94876E-15
RA3424       23602           0      0.41938E+09
RA3425       23601       23602      0.53870E-02
VA3425       23600       23601 AC   0.00000E+00
LA3425       23599       23600      0.12767E-08
CA3426       23605           0      0.94876E-15
RA3426       23605           0      0.41938E+09
RA3427       23604       23605      0.53870E-02
VA3427       23603       23604 AC   0.00000E+00
LA3427       23602       23603      0.12767E-08
CA3428       23608           0      0.94876E-15
RA3428       23608           0      0.41938E+09
RA3429       23607       23608      0.53870E-02
VA3429       23606       23607 AC   0.00000E+00
LA3429       23605       23606      0.12767E-08
CA3430       23611           0      0.94876E-15
RA3430       23611           0      0.41938E+09
RA3431       23610       23611      0.53870E-02
VA3431       23609       23610 AC   0.00000E+00
LA3431       23608       23609      0.12767E-08
CA3432       23614           0      0.94876E-15
RA3432       23614           0      0.41938E+09
RA3433       23613       23614      0.53870E-02
VA3433       23612       23613 AC   0.00000E+00
LA3433       23611       23612      0.12767E-08
CA3434       23617           0      0.50472E-14
RA3434       23617           0      0.41938E+09
RA3435       23616       23617      0.53870E-02
VA3435       23615       23616 AC   0.00000E+00
LA3435       23614       23615      0.12767E-08
CA3436       23618           0      0.50472E-14
RA3436       23618           0      0.41938E+09
CA3437       23621           0      0.94876E-15
RA3437       23621           0      0.41938E+09
RA3438       23620       23621      0.53870E-02
VA3438       23619       23620 AC   0.00000E+00
LA3438       23618       23619      0.12767E-08
CA3439       23624           0      0.94876E-15
RA3439       23624           0      0.41938E+09
RA3440       23623       23624      0.53870E-02
VA3440       23622       23623 AC   0.00000E+00
LA3440       23621       23622      0.12767E-08
CA3441       23627           0      0.94876E-15
RA3441       23627           0      0.41938E+09
RA3442       23626       23627      0.53870E-02
VA3442       23625       23626 AC   0.00000E+00
LA3442       23624       23625      0.12767E-08
CA3443       23630           0      0.94876E-15
RA3443       23630           0      0.41938E+09
RA3444       23629       23630      0.53870E-02
VA3444       23628       23629 AC   0.00000E+00
LA3444       23627       23628      0.12767E-08
CA3445       23633           0      0.94876E-15
RA3445       23633           0      0.41938E+09
RA3446       23632       23633      0.53870E-02
VA3446       23631       23632 AC   0.00000E+00
LA3446       23630       23631      0.12767E-08
CA3447       23636           0      0.94876E-15
RA3447       23636           0      0.41938E+09
RA3448       23635       23636      0.53870E-02
VA3448       23634       23635 AC   0.00000E+00
LA3448       23633       23634      0.12767E-08
CA3449       23639           0      0.94876E-15
RA3449       23639           0      0.41938E+09
RA3450       23638       23639      0.53870E-02
VA3450       23637       23638 AC   0.00000E+00
LA3450       23636       23637      0.12767E-08
CA3451       23642           0      0.94876E-15
RA3451       23642           0      0.41938E+09
RA3452       23641       23642      0.53870E-02
VA3452       23640       23641 AC   0.00000E+00
LA3452       23639       23640      0.12767E-08
CA3453       23645           0      0.94876E-15
RA3453       23645           0      0.41938E+09
RA3454       23644       23645      0.53870E-02
VA3454       23643       23644 AC   0.00000E+00
LA3454       23642       23643      0.12767E-08
CA3455       23648           0      0.50472E-14
RA3455       23648           0      0.41938E+09
RA3456       23647       23648      0.53870E-02
VA3456       23646       23647 AC   0.00000E+00
LA3456       23645       23646      0.12767E-08
CA3457       23649           0      0.50472E-14
RA3457       23649           0      0.41938E+09
CA3458       23652           0      0.94876E-15
RA3458       23652           0      0.41938E+09
RA3459       23651       23652      0.53870E-02
VA3459       23650       23651 AC   0.00000E+00
LA3459       23649       23650      0.12767E-08
CA3460       23655           0      0.94876E-15
RA3460       23655           0      0.41938E+09
RA3461       23654       23655      0.53870E-02
VA3461       23653       23654 AC   0.00000E+00
LA3461       23652       23653      0.12767E-08
CA3462       23658           0      0.94876E-15
RA3462       23658           0      0.41938E+09
RA3463       23657       23658      0.53870E-02
VA3463       23656       23657 AC   0.00000E+00
LA3463       23655       23656      0.12767E-08
CA3464       23661           0      0.94876E-15
RA3464       23661           0      0.41938E+09
RA3465       23660       23661      0.53870E-02
VA3465       23659       23660 AC   0.00000E+00
LA3465       23658       23659      0.12767E-08
CA3466       23664           0      0.94876E-15
RA3466       23664           0      0.41938E+09
RA3467       23663       23664      0.53870E-02
VA3467       23662       23663 AC   0.00000E+00
LA3467       23661       23662      0.12767E-08
CA3468       23667           0      0.94876E-15
RA3468       23667           0      0.41938E+09
RA3469       23666       23667      0.53870E-02
VA3469       23665       23666 AC   0.00000E+00
LA3469       23664       23665      0.12767E-08
CA3470       23670           0      0.94876E-15
RA3470       23670           0      0.41938E+09
RA3471       23669       23670      0.53870E-02
VA3471       23668       23669 AC   0.00000E+00
LA3471       23667       23668      0.12767E-08
CA3472       23673           0      0.94876E-15
RA3472       23673           0      0.41938E+09
RA3473       23672       23673      0.53870E-02
VA3473       23671       23672 AC   0.00000E+00
LA3473       23670       23671      0.12767E-08
CA3474       23676           0      0.94876E-15
RA3474       23676           0      0.41938E+09
RA3475       23675       23676      0.53870E-02
VA3475       23674       23675 AC   0.00000E+00
LA3475       23673       23674      0.12767E-08
CA3476       23679           0      0.50472E-14
RA3476       23679           0      0.41938E+09
RA3477       23678       23679      0.53870E-02
VA3477       23677       23678 AC   0.00000E+00
LA3477       23676       23677      0.12767E-08
CA3478       23680           0      0.50472E-14
RA3478       23680           0      0.41938E+09
CA3479       23683           0      0.94876E-15
RA3479       23683           0      0.41938E+09
RA3480       23682       23683      0.53870E-02
VA3480       23681       23682 AC   0.00000E+00
LA3480       23680       23681      0.12767E-08
CA3481       23686           0      0.94876E-15
RA3481       23686           0      0.41938E+09
RA3482       23685       23686      0.53870E-02
VA3482       23684       23685 AC   0.00000E+00
LA3482       23683       23684      0.12767E-08
CA3483       23689           0      0.94876E-15
RA3483       23689           0      0.41938E+09
RA3484       23688       23689      0.53870E-02
VA3484       23687       23688 AC   0.00000E+00
LA3484       23686       23687      0.12767E-08
CA3485       23692           0      0.94876E-15
RA3485       23692           0      0.41938E+09
RA3486       23691       23692      0.53870E-02
VA3486       23690       23691 AC   0.00000E+00
LA3486       23689       23690      0.12767E-08
CA3487       23695           0      0.94876E-15
RA3487       23695           0      0.41938E+09
RA3488       23694       23695      0.53870E-02
VA3488       23693       23694 AC   0.00000E+00
LA3488       23692       23693      0.12767E-08
CA3489       23698           0      0.94876E-15
RA3489       23698           0      0.41938E+09
RA3490       23697       23698      0.53870E-02
VA3490       23696       23697 AC   0.00000E+00
LA3490       23695       23696      0.12767E-08
CA3491       23701           0      0.94876E-15
RA3491       23701           0      0.41938E+09
RA3492       23700       23701      0.53870E-02
VA3492       23699       23700 AC   0.00000E+00
LA3492       23698       23699      0.12767E-08
CA3493       23704           0      0.94876E-15
RA3493       23704           0      0.41938E+09
RA3494       23703       23704      0.53870E-02
VA3494       23702       23703 AC   0.00000E+00
LA3494       23701       23702      0.12767E-08
CA3495       23707           0      0.94876E-15
RA3495       23707           0      0.41938E+09
RA3496       23706       23707      0.53870E-02
VA3496       23705       23706 AC   0.00000E+00
LA3496       23704       23705      0.12767E-08
CA3497       23710           0      0.50472E-14
RA3497       23710           0      0.41938E+09
RA3498       23709       23710      0.53870E-02
VA3498       23708       23709 AC   0.00000E+00
LA3498       23707       23708      0.12767E-08
RA3499           0       23711      0.26935E-02
VA3499       23711       23712 AC   0.00000E+00
LA3499       23712       23713      0.63469E-10
CA3500       23713           0      0.51279E-14
RA3500       23713           0      0.41938E+09
CA3501       23716           0      0.51279E-14
RA3501       23716           0      0.41938E+09
RA3502       23715       23716      0.53870E-02
VA3502       23714       23715 AC   0.00000E+00
LA3502       23713       23714      0.12694E-09
CA3503       23719           0      0.51279E-14
RA3503       23719           0      0.41938E+09
RA3504       23718       23719      0.53870E-02
VA3504       23717       23718 AC   0.00000E+00
LA3504       23716       23717      0.12694E-09
CA3505       23722           0      0.51279E-14
RA3505       23722           0      0.41938E+09
RA3506       23721       23722      0.53870E-02
VA3506       23720       23721 AC   0.00000E+00
LA3506       23719       23720      0.12694E-09
CA3507       23725           0      0.51279E-14
RA3507       23725           0      0.41938E+09
RA3508       23724       23725      0.53870E-02
VA3508       23723       23724 AC   0.00000E+00
LA3508       23722       23723      0.12694E-09
CA3509       23728           0      0.51279E-14
RA3509       23728           0      0.41938E+09
RA3510       23727       23728      0.53870E-02
VA3510       23726       23727 AC   0.00000E+00
LA3510       23725       23726      0.12694E-09
CA3511       23731           0      0.51279E-14
RA3511       23731           0      0.41938E+09
RA3512       23730       23731      0.53870E-02
VA3512       23729       23730 AC   0.00000E+00
LA3512       23728       23729      0.12694E-09
CA3513       23734           0      0.51279E-14
RA3513       23734           0      0.41938E+09
RA3514       23733       23734      0.53870E-02
VA3514       23732       23733 AC   0.00000E+00
LA3514       23731       23732      0.12694E-09
CA3515       23737           0      0.51279E-14
RA3515       23737           0      0.41938E+09
RA3516       23736       23737      0.53870E-02
VA3516       23735       23736 AC   0.00000E+00
LA3516       23734       23735      0.12694E-09
CA3517       23740           0      0.94876E-15
RA3517       23740           0      0.41938E+09
RA3518       23739       23740      0.53870E-02
VA3518       23738       23739 AC   0.00000E+00
LA3518       23737       23738      0.70182E-09
CA3519       23743           0      0.94876E-15
RA3519       23743           0      0.41938E+09
RA3520       23742       23743      0.53870E-02
VA3520       23741       23742 AC   0.00000E+00
LA3520       23740       23741      0.12767E-08
CA3521       23746           0      0.94876E-15
RA3521       23746           0      0.41938E+09
RA3522       23745       23746      0.53870E-02
VA3522       23744       23745 AC   0.00000E+00
LA3522       23743       23744      0.12767E-08
CA3523       23749           0      0.94876E-15
RA3523       23749           0      0.41938E+09
RA3524       23748       23749      0.53870E-02
VA3524       23747       23748 AC   0.00000E+00
LA3524       23746       23747      0.12767E-08
CA3525       23752           0      0.94876E-15
RA3525       23752           0      0.41938E+09
RA3526       23751       23752      0.53870E-02
VA3526       23750       23751 AC   0.00000E+00
LA3526       23749       23750      0.12767E-08
CA3527       23755           0      0.94876E-15
RA3527       23755           0      0.41938E+09
RA3528       23754       23755      0.53870E-02
VA3528       23753       23754 AC   0.00000E+00
LA3528       23752       23753      0.12767E-08
CA3529       23758           0      0.94876E-15
RA3529       23758           0      0.41938E+09
RA3530       23757       23758      0.53870E-02
VA3530       23756       23757 AC   0.00000E+00
LA3530       23755       23756      0.12767E-08
CA3531       23761           0      0.94876E-15
RA3531       23761           0      0.41938E+09
RA3532       23760       23761      0.53870E-02
VA3532       23759       23760 AC   0.00000E+00
LA3532       23758       23759      0.12767E-08
CA3533       23764           0      0.94876E-15
RA3533       23764           0      0.41938E+09
RA3534       23763       23764      0.53870E-02
VA3534       23762       23763 AC   0.00000E+00
LA3534       23761       23762      0.12767E-08
CA3535       23767           0      0.94876E-15
RA3535       23767           0      0.41938E+09
RA3536       23766       23767      0.53870E-02
VA3536       23765       23766 AC   0.00000E+00
LA3536       23764       23765      0.12767E-08
CA3537       23770           0      0.51451E-14
RA3537       23770           0      0.41938E+09
RA3538       23769       23770      0.53870E-02
VA3538       23768       23769 AC   0.00000E+00
LA3538       23767       23768      0.12767E-08
RA3539           0       23771      0.26935E-02
VA3539       23771       23772 AC   0.00000E+00
LA3539       23772       23773      0.63835E-09
CA3540       23773           0      0.94876E-15
RA3540       23773           0      0.41938E+09
CA3541       23776           0      0.94876E-15
RA3541       23776           0      0.41938E+09
RA3542       23775       23776      0.53870E-02
VA3542       23774       23775 AC   0.00000E+00
LA3542       23773       23774      0.12767E-08
CA3543       23779           0      0.94876E-15
RA3543       23779           0      0.41938E+09
RA3544       23778       23779      0.53870E-02
VA3544       23777       23778 AC   0.00000E+00
LA3544       23776       23777      0.12767E-08
CA3545       23782           0      0.94876E-15
RA3545       23782           0      0.41938E+09
RA3546       23781       23782      0.53870E-02
VA3546       23780       23781 AC   0.00000E+00
LA3546       23779       23780      0.12767E-08
CA3547       23785           0      0.94876E-15
RA3547       23785           0      0.41938E+09
RA3548       23784       23785      0.53870E-02
VA3548       23783       23784 AC   0.00000E+00
LA3548       23782       23783      0.12767E-08
CA3549       23788           0      0.94876E-15
RA3549       23788           0      0.41938E+09
RA3550       23787       23788      0.53870E-02
VA3550       23786       23787 AC   0.00000E+00
LA3550       23785       23786      0.12767E-08
CA3551       23791           0      0.94876E-15
RA3551       23791           0      0.41938E+09
RA3552       23790       23791      0.53870E-02
VA3552       23789       23790 AC   0.00000E+00
LA3552       23788       23789      0.12767E-08
CA3553       23794           0      0.94876E-15
RA3553       23794           0      0.41938E+09
RA3554       23793       23794      0.53870E-02
VA3554       23792       23793 AC   0.00000E+00
LA3554       23791       23792      0.12767E-08
CA3555       23797           0      0.94876E-15
RA3555       23797           0      0.41938E+09
RA3556       23796       23797      0.53870E-02
VA3556       23795       23796 AC   0.00000E+00
LA3556       23794       23795      0.12767E-08
CA3557       23800           0      0.94876E-15
RA3557       23800           0      0.41938E+09
RA3558       23799       23800      0.53870E-02
VA3558       23798       23799 AC   0.00000E+00
LA3558       23797       23798      0.12767E-08
CA3559       23803           0      0.94876E-15
RA3559       23803           0      0.41938E+09
RA3560       23802       23803      0.53870E-02
VA3560       23801       23802 AC   0.00000E+00
LA3560       23800       23801      0.12767E-08
CA3561       23806           0      0.94876E-15
RA3561       23806           0      0.41938E+09
RA3562       23805       23806      0.53870E-02
VA3562       23804       23805 AC   0.00000E+00
LA3562       23803       23804      0.12767E-08
CA3563       23809           0      0.94876E-15
RA3563       23809           0      0.41938E+09
RA3564       23808       23809      0.53870E-02
VA3564       23807       23808 AC   0.00000E+00
LA3564       23806       23807      0.12767E-08
CA3565       23812           0      0.94876E-15
RA3565       23812           0      0.41938E+09
RA3566       23811       23812      0.53870E-02
VA3566       23810       23811 AC   0.00000E+00
LA3566       23809       23810      0.12767E-08
CA3567       23815           0      0.94876E-15
RA3567       23815           0      0.41938E+09
RA3568       23814       23815      0.53870E-02
VA3568       23813       23814 AC   0.00000E+00
LA3568       23812       23813      0.12767E-08
CA3569       23818           0      0.94876E-15
RA3569       23818           0      0.41938E+09
RA3570       23817       23818      0.53870E-02
VA3570       23816       23817 AC   0.00000E+00
LA3570       23815       23816      0.12767E-08
CA3571       23821           0      0.94876E-15
RA3571       23821           0      0.41938E+09
RA3572       23820       23821      0.53870E-02
VA3572       23819       23820 AC   0.00000E+00
LA3572       23818       23819      0.12767E-08
CA3573       23824           0      0.94876E-15
RA3573       23824           0      0.41938E+09
RA3574       23823       23824      0.53870E-02
VA3574       23822       23823 AC   0.00000E+00
LA3574       23821       23822      0.12767E-08
CA3575       23827           0      0.94876E-15
RA3575       23827           0      0.41938E+09
RA3576       23826       23827      0.53870E-02
VA3576       23825       23826 AC   0.00000E+00
LA3576       23824       23825      0.12767E-08
CA3577       23830           0      0.51451E-14
RA3577       23830           0      0.41938E+09
RA3578       23829       23830      0.53870E-02
VA3578       23828       23829 AC   0.00000E+00
LA3578       23827       23828      0.12767E-08
RA3579           0       23831      0.26935E-02
VA3579       23831       23832 AC   0.00000E+00
LA3579       23832       23833      0.63835E-09
CA3580       23833           0      0.94876E-15
RA3580       23833           0      0.41938E+09
CA3581       23836           0      0.94876E-15
RA3581       23836           0      0.41938E+09
RA3582       23835       23836      0.53870E-02
VA3582       23834       23835 AC   0.00000E+00
LA3582       23833       23834      0.12767E-08
CA3583       23839           0      0.94876E-15
RA3583       23839           0      0.41938E+09
RA3584       23838       23839      0.53870E-02
VA3584       23837       23838 AC   0.00000E+00
LA3584       23836       23837      0.12767E-08
CA3585       23842           0      0.94876E-15
RA3585       23842           0      0.41938E+09
RA3586       23841       23842      0.53870E-02
VA3586       23840       23841 AC   0.00000E+00
LA3586       23839       23840      0.12767E-08
CA3587       23845           0      0.94876E-15
RA3587       23845           0      0.41938E+09
RA3588       23844       23845      0.53870E-02
VA3588       23843       23844 AC   0.00000E+00
LA3588       23842       23843      0.12767E-08
CA3589       23848           0      0.94876E-15
RA3589       23848           0      0.41938E+09
RA3590       23847       23848      0.53870E-02
VA3590       23846       23847 AC   0.00000E+00
LA3590       23845       23846      0.12767E-08
CA3591       23851           0      0.94876E-15
RA3591       23851           0      0.41938E+09
RA3592       23850       23851      0.53870E-02
VA3592       23849       23850 AC   0.00000E+00
LA3592       23848       23849      0.12767E-08
CA3593       23854           0      0.94876E-15
RA3593       23854           0      0.41938E+09
RA3594       23853       23854      0.53870E-02
VA3594       23852       23853 AC   0.00000E+00
LA3594       23851       23852      0.12767E-08
CA3595       23857           0      0.94876E-15
RA3595       23857           0      0.41938E+09
RA3596       23856       23857      0.53870E-02
VA3596       23855       23856 AC   0.00000E+00
LA3596       23854       23855      0.12767E-08
CA3597       23860           0      0.94876E-15
RA3597       23860           0      0.41938E+09
RA3598       23859       23860      0.53870E-02
VA3598       23858       23859 AC   0.00000E+00
LA3598       23857       23858      0.12767E-08
CA3599       23863           0      0.94876E-15
RA3599       23863           0      0.41938E+09
RA3600       23862       23863      0.53870E-02
VA3600       23861       23862 AC   0.00000E+00
LA3600       23860       23861      0.12767E-08
CA3601       23866           0      0.94876E-15
RA3601       23866           0      0.41938E+09
RA3602       23865       23866      0.53870E-02
VA3602       23864       23865 AC   0.00000E+00
LA3602       23863       23864      0.12767E-08
CA3603       23869           0      0.94876E-15
RA3603       23869           0      0.41938E+09
RA3604       23868       23869      0.53870E-02
VA3604       23867       23868 AC   0.00000E+00
LA3604       23866       23867      0.12767E-08
CA3605       23872           0      0.94876E-15
RA3605       23872           0      0.41938E+09
RA3606       23871       23872      0.53870E-02
VA3606       23870       23871 AC   0.00000E+00
LA3606       23869       23870      0.12767E-08
CA3607       23875           0      0.94876E-15
RA3607       23875           0      0.41938E+09
RA3608       23874       23875      0.53870E-02
VA3608       23873       23874 AC   0.00000E+00
LA3608       23872       23873      0.12767E-08
CA3609       23878           0      0.94876E-15
RA3609       23878           0      0.41938E+09
RA3610       23877       23878      0.53870E-02
VA3610       23876       23877 AC   0.00000E+00
LA3610       23875       23876      0.12767E-08
CA3611       23881           0      0.94876E-15
RA3611       23881           0      0.41938E+09
RA3612       23880       23881      0.53870E-02
VA3612       23879       23880 AC   0.00000E+00
LA3612       23878       23879      0.12767E-08
CA3613       23884           0      0.94876E-15
RA3613       23884           0      0.41938E+09
RA3614       23883       23884      0.53870E-02
VA3614       23882       23883 AC   0.00000E+00
LA3614       23881       23882      0.12767E-08
CA3615       23887           0      0.94876E-15
RA3615       23887           0      0.41938E+09
RA3616       23886       23887      0.53870E-02
VA3616       23885       23886 AC   0.00000E+00
LA3616       23884       23885      0.12767E-08
CA3617       23890           0      0.51451E-14
RA3617       23890           0      0.41938E+09
RA3618       23889       23890      0.53870E-02
VA3618       23888       23889 AC   0.00000E+00
LA3618       23887       23888      0.12767E-08
CA3619       23891           0      0.50977E-14
RA3619       23891           0      0.41938E+09
CA3620       23894           0      0.51086E-14
RA3620       23894           0      0.41938E+09
RA3621       23893       23894      0.53870E-02
VA3621       23892       23893 AC   0.00000E+00
LA3621       23891       23892      0.12934E-09
CA3622       23897           0      0.51086E-14
RA3622       23897           0      0.41938E+09
RA3623       23896       23897      0.53870E-02
VA3623       23895       23896 AC   0.00000E+00
LA3623       23894       23895      0.12934E-09
CA3624       23900           0      0.51086E-14
RA3624       23900           0      0.41938E+09
RA3625       23899       23900      0.53870E-02
VA3625       23898       23899 AC   0.00000E+00
LA3625       23897       23898      0.12934E-09
CA3626       23903           0      0.51086E-14
RA3626       23903           0      0.41938E+09
RA3627       23902       23903      0.53870E-02
VA3627       23901       23902 AC   0.00000E+00
LA3627       23900       23901      0.12934E-09
CA3628       23906           0      0.51086E-14
RA3628       23906           0      0.41938E+09
RA3629       23905       23906      0.53870E-02
VA3629       23904       23905 AC   0.00000E+00
LA3629       23903       23904      0.12934E-09
CA3630       23909           0      0.51086E-14
RA3630       23909           0      0.41938E+09
RA3631       23908       23909      0.53870E-02
VA3631       23907       23908 AC   0.00000E+00
LA3631       23906       23907      0.12934E-09
CA3632       23912           0      0.51086E-14
RA3632       23912           0      0.41938E+09
RA3633       23911       23912      0.53870E-02
VA3633       23910       23911 AC   0.00000E+00
LA3633       23909       23910      0.12934E-09
CA3634       23915           0      0.51086E-14
RA3634       23915           0      0.41938E+09
RA3635       23914       23915      0.53870E-02
VA3635       23913       23914 AC   0.00000E+00
LA3635       23912       23913      0.12934E-09
CA3636       23918           0      0.51086E-14
RA3636       23918           0      0.41938E+09
RA3637       23917       23918      0.53870E-02
VA3637       23916       23917 AC   0.00000E+00
LA3637       23915       23916      0.12934E-09
CA3638       23921           0      0.51086E-14
RA3638       23921           0      0.41938E+09
RA3639       23920       23921      0.53870E-02
VA3639       23919       23920 AC   0.00000E+00
LA3639       23918       23919      0.12934E-09
CA3640       23924           0      0.51086E-14
RA3640       23924           0      0.41938E+09
RA3641       23923       23924      0.53870E-02
VA3641       23922       23923 AC   0.00000E+00
LA3641       23921       23922      0.12934E-09
CA3642       23927           0      0.51086E-14
RA3642       23927           0      0.41938E+09
RA3643       23926       23927      0.53870E-02
VA3643       23925       23926 AC   0.00000E+00
LA3643       23924       23925      0.12934E-09
CA3644       23930           0      0.33732E-14
RA3644       23930           0      0.41938E+09
RA3645       23929       23930      0.53870E-02
VA3645       23928       23929 AC   0.00000E+00
LA3645       23927       23928      0.12934E-09
RA3646           0       23931      0.26935E-02
VA3646       23931       23932 AC   0.00000E+00
LA3646       23932       23933      0.63835E-09
CA3647       23933           0      0.94876E-15
RA3647       23933           0      0.41938E+09
CA3648       23936           0      0.94876E-15
RA3648       23936           0      0.41938E+09
RA3649       23935       23936      0.53870E-02
VA3649       23934       23935 AC   0.00000E+00
LA3649       23933       23934      0.12767E-08
CA3650       23939           0      0.94876E-15
RA3650       23939           0      0.41938E+09
RA3651       23938       23939      0.53870E-02
VA3651       23937       23938 AC   0.00000E+00
LA3651       23936       23937      0.12767E-08
CA3652       23942           0      0.94876E-15
RA3652       23942           0      0.41938E+09
RA3653       23941       23942      0.53870E-02
VA3653       23940       23941 AC   0.00000E+00
LA3653       23939       23940      0.12767E-08
CA3654       23945           0      0.94876E-15
RA3654       23945           0      0.41938E+09
RA3655       23944       23945      0.53870E-02
VA3655       23943       23944 AC   0.00000E+00
LA3655       23942       23943      0.12767E-08
CA3656       23948           0      0.94876E-15
RA3656       23948           0      0.41938E+09
RA3657       23947       23948      0.53870E-02
VA3657       23946       23947 AC   0.00000E+00
LA3657       23945       23946      0.12767E-08
CA3658       23951           0      0.94876E-15
RA3658       23951           0      0.41938E+09
RA3659       23950       23951      0.53870E-02
VA3659       23949       23950 AC   0.00000E+00
LA3659       23948       23949      0.12767E-08
CA3660       23954           0      0.94876E-15
RA3660       23954           0      0.41938E+09
RA3661       23953       23954      0.53870E-02
VA3661       23952       23953 AC   0.00000E+00
LA3661       23951       23952      0.12767E-08
CA3662       23957           0      0.94876E-15
RA3662       23957           0      0.41938E+09
RA3663       23956       23957      0.53870E-02
VA3663       23955       23956 AC   0.00000E+00
LA3663       23954       23955      0.12767E-08
CA3664       23960           0      0.94876E-15
RA3664       23960           0      0.41938E+09
RA3665       23959       23960      0.53870E-02
VA3665       23958       23959 AC   0.00000E+00
LA3665       23957       23958      0.12767E-08
CA3666       23963           0      0.94876E-15
RA3666       23963           0      0.41938E+09
RA3667       23962       23963      0.53870E-02
VA3667       23961       23962 AC   0.00000E+00
LA3667       23960       23961      0.12767E-08
CA3668       23966           0      0.94876E-15
RA3668       23966           0      0.41938E+09
RA3669       23965       23966      0.53870E-02
VA3669       23964       23965 AC   0.00000E+00
LA3669       23963       23964      0.12767E-08
CA3670       23969           0      0.94876E-15
RA3670       23969           0      0.41938E+09
RA3671       23968       23969      0.53870E-02
VA3671       23967       23968 AC   0.00000E+00
LA3671       23966       23967      0.12767E-08
CA3672       23972           0      0.94876E-15
RA3672       23972           0      0.41938E+09
RA3673       23971       23972      0.53870E-02
VA3673       23970       23971 AC   0.00000E+00
LA3673       23969       23970      0.12767E-08
CA3674       23975           0      0.94876E-15
RA3674       23975           0      0.41938E+09
RA3675       23974       23975      0.53870E-02
VA3675       23973       23974 AC   0.00000E+00
LA3675       23972       23973      0.12767E-08
CA3676       23978           0      0.94876E-15
RA3676       23978           0      0.41938E+09
RA3677       23977       23978      0.53870E-02
VA3677       23976       23977 AC   0.00000E+00
LA3677       23975       23976      0.12767E-08
CA3678       23981           0      0.94876E-15
RA3678       23981           0      0.41938E+09
RA3679       23980       23981      0.53870E-02
VA3679       23979       23980 AC   0.00000E+00
LA3679       23978       23979      0.12767E-08
CA3680       23984           0      0.94876E-15
RA3680       23984           0      0.41938E+09
RA3681       23983       23984      0.53870E-02
VA3681       23982       23983 AC   0.00000E+00
LA3681       23981       23982      0.12767E-08
CA3682       23987           0      0.94876E-15
RA3682       23987           0      0.41938E+09
RA3683       23986       23987      0.53870E-02
VA3683       23985       23986 AC   0.00000E+00
LA3683       23984       23985      0.12767E-08
CA3684       23990           0      0.51451E-14
RA3684       23990           0      0.41938E+09
RA3685       23989       23990      0.53870E-02
VA3685       23988       23989 AC   0.00000E+00
LA3685       23987       23988      0.12767E-08
CA3686       23991           0      0.50868E-14
RA3686       23991           0      0.41938E+09
CA3687       23994           0      0.94876E-15
RA3687       23994           0      0.41938E+09
RA3688       23993       23994      0.53870E-02
VA3688       23992       23993 AC   0.00000E+00
LA3688       23991       23992      0.12767E-08
CA3689       23997           0      0.94876E-15
RA3689       23997           0      0.41938E+09
RA3690       23996       23997      0.53870E-02
VA3690       23995       23996 AC   0.00000E+00
LA3690       23994       23995      0.12767E-08
CA3691       24000           0      0.94876E-15
RA3691       24000           0      0.41938E+09
RA3692       23999       24000      0.53870E-02
VA3692       23998       23999 AC   0.00000E+00
LA3692       23997       23998      0.12767E-08
CA3693       24003           0      0.94876E-15
RA3693       24003           0      0.41938E+09
RA3694       24002       24003      0.53870E-02
VA3694       24001       24002 AC   0.00000E+00
LA3694       24000       24001      0.12767E-08
CA3695       24006           0      0.94876E-15
RA3695       24006           0      0.41938E+09
RA3696       24005       24006      0.53870E-02
VA3696       24004       24005 AC   0.00000E+00
LA3696       24003       24004      0.12767E-08
CA3697       24009           0      0.94876E-15
RA3697       24009           0      0.41938E+09
RA3698       24008       24009      0.53870E-02
VA3698       24007       24008 AC   0.00000E+00
LA3698       24006       24007      0.12767E-08
CA3699       24012           0      0.94876E-15
RA3699       24012           0      0.41938E+09
RA3700       24011       24012      0.53870E-02
VA3700       24010       24011 AC   0.00000E+00
LA3700       24009       24010      0.12767E-08
CA3701       24015           0      0.94876E-15
RA3701       24015           0      0.41938E+09
RA3702       24014       24015      0.53870E-02
VA3702       24013       24014 AC   0.00000E+00
LA3702       24012       24013      0.12767E-08
CA3703       24018           0      0.94876E-15
RA3703       24018           0      0.41938E+09
RA3704       24017       24018      0.53870E-02
VA3704       24016       24017 AC   0.00000E+00
LA3704       24015       24016      0.12767E-08
CA3705       24021           0      0.94876E-15
RA3705       24021           0      0.41938E+09
RA3706       24020       24021      0.53870E-02
VA3706       24019       24020 AC   0.00000E+00
LA3706       24018       24019      0.12767E-08
CA3707       24024           0      0.94876E-15
RA3707       24024           0      0.41938E+09
RA3708       24023       24024      0.53870E-02
VA3708       24022       24023 AC   0.00000E+00
LA3708       24021       24022      0.12767E-08
CA3709       24027           0      0.94876E-15
RA3709       24027           0      0.41938E+09
RA3710       24026       24027      0.53870E-02
VA3710       24025       24026 AC   0.00000E+00
LA3710       24024       24025      0.12767E-08
CA3711       24030           0      0.16377E-14
RA3711       24030           0      0.41938E+09
RA3712       24029       24030      0.53870E-02
VA3712       24028       24029 AC   0.00000E+00
LA3712       24027       24028      0.12767E-08
RA3713           0       24031      0.26935E-02
VA3713       24031       24032 AC   0.00000E+00
LA3713       24032       24033      0.63835E-09
CA3714       24033           0      0.94876E-15
RA3714       24033           0      0.41938E+09
CA3715       24036           0      0.94876E-15
RA3715       24036           0      0.41938E+09
RA3716       24035       24036      0.53870E-02
VA3716       24034       24035 AC   0.00000E+00
LA3716       24033       24034      0.12767E-08
CA3717       24039           0      0.94876E-15
RA3717       24039           0      0.41938E+09
RA3718       24038       24039      0.53870E-02
VA3718       24037       24038 AC   0.00000E+00
LA3718       24036       24037      0.12767E-08
CA3719       24042           0      0.94876E-15
RA3719       24042           0      0.41938E+09
RA3720       24041       24042      0.53870E-02
VA3720       24040       24041 AC   0.00000E+00
LA3720       24039       24040      0.12767E-08
CA3721       24045           0      0.94876E-15
RA3721       24045           0      0.41938E+09
RA3722       24044       24045      0.53870E-02
VA3722       24043       24044 AC   0.00000E+00
LA3722       24042       24043      0.12767E-08
CA3723       24048           0      0.94876E-15
RA3723       24048           0      0.41938E+09
RA3724       24047       24048      0.53870E-02
VA3724       24046       24047 AC   0.00000E+00
LA3724       24045       24046      0.12767E-08
CA3725       24051           0      0.94876E-15
RA3725       24051           0      0.41938E+09
RA3726       24050       24051      0.53870E-02
VA3726       24049       24050 AC   0.00000E+00
LA3726       24048       24049      0.12767E-08
CA3727       24054           0      0.94876E-15
RA3727       24054           0      0.41938E+09
RA3728       24053       24054      0.53870E-02
VA3728       24052       24053 AC   0.00000E+00
LA3728       24051       24052      0.12767E-08
CA3729       24057           0      0.94876E-15
RA3729       24057           0      0.41938E+09
RA3730       24056       24057      0.53870E-02
VA3730       24055       24056 AC   0.00000E+00
LA3730       24054       24055      0.12767E-08
CA3731       24060           0      0.94876E-15
RA3731       24060           0      0.41938E+09
RA3732       24059       24060      0.53870E-02
VA3732       24058       24059 AC   0.00000E+00
LA3732       24057       24058      0.12767E-08
CA3733       24063           0      0.94876E-15
RA3733       24063           0      0.41938E+09
RA3734       24062       24063      0.53870E-02
VA3734       24061       24062 AC   0.00000E+00
LA3734       24060       24061      0.12767E-08
CA3735       24066           0      0.94876E-15
RA3735       24066           0      0.41938E+09
RA3736       24065       24066      0.53870E-02
VA3736       24064       24065 AC   0.00000E+00
LA3736       24063       24064      0.12767E-08
CA3737       24069           0      0.94876E-15
RA3737       24069           0      0.41938E+09
RA3738       24068       24069      0.53870E-02
VA3738       24067       24068 AC   0.00000E+00
LA3738       24066       24067      0.12767E-08
CA3739       24072           0      0.94876E-15
RA3739       24072           0      0.41938E+09
RA3740       24071       24072      0.53870E-02
VA3740       24070       24071 AC   0.00000E+00
LA3740       24069       24070      0.12767E-08
CA3741       24075           0      0.94876E-15
RA3741       24075           0      0.41938E+09
RA3742       24074       24075      0.53870E-02
VA3742       24073       24074 AC   0.00000E+00
LA3742       24072       24073      0.12767E-08
CA3743       24078           0      0.94876E-15
RA3743       24078           0      0.41938E+09
RA3744       24077       24078      0.53870E-02
VA3744       24076       24077 AC   0.00000E+00
LA3744       24075       24076      0.12767E-08
CA3745       24081           0      0.94876E-15
RA3745       24081           0      0.41938E+09
RA3746       24080       24081      0.53870E-02
VA3746       24079       24080 AC   0.00000E+00
LA3746       24078       24079      0.12767E-08
CA3747       24084           0      0.94876E-15
RA3747       24084           0      0.41938E+09
RA3748       24083       24084      0.53870E-02
VA3748       24082       24083 AC   0.00000E+00
LA3748       24081       24082      0.12767E-08
CA3749       24087           0      0.94876E-15
RA3749       24087           0      0.41938E+09
RA3750       24086       24087      0.53870E-02
VA3750       24085       24086 AC   0.00000E+00
LA3750       24084       24085      0.12767E-08
CA3751       24090           0      0.51451E-14
RA3751       24090           0      0.41938E+09
RA3752       24089       24090      0.53870E-02
VA3752       24088       24089 AC   0.00000E+00
LA3752       24087       24088      0.12767E-08
CA3753       24091           0      0.50868E-14
RA3753       24091           0      0.41938E+09
CA3754       24094           0      0.94876E-15
RA3754       24094           0      0.41938E+09
RA3755       24093       24094      0.53870E-02
VA3755       24092       24093 AC   0.00000E+00
LA3755       24091       24092      0.12767E-08
CA3756       24097           0      0.94876E-15
RA3756       24097           0      0.41938E+09
RA3757       24096       24097      0.53870E-02
VA3757       24095       24096 AC   0.00000E+00
LA3757       24094       24095      0.12767E-08
CA3758       24100           0      0.94876E-15
RA3758       24100           0      0.41938E+09
RA3759       24099       24100      0.53870E-02
VA3759       24098       24099 AC   0.00000E+00
LA3759       24097       24098      0.12767E-08
CA3760       24103           0      0.94876E-15
RA3760       24103           0      0.41938E+09
RA3761       24102       24103      0.53870E-02
VA3761       24101       24102 AC   0.00000E+00
LA3761       24100       24101      0.12767E-08
CA3762       24106           0      0.94876E-15
RA3762       24106           0      0.41938E+09
RA3763       24105       24106      0.53870E-02
VA3763       24104       24105 AC   0.00000E+00
LA3763       24103       24104      0.12767E-08
CA3764       24109           0      0.94876E-15
RA3764       24109           0      0.41938E+09
RA3765       24108       24109      0.53870E-02
VA3765       24107       24108 AC   0.00000E+00
LA3765       24106       24107      0.12767E-08
CA3766       24112           0      0.94876E-15
RA3766       24112           0      0.41938E+09
RA3767       24111       24112      0.53870E-02
VA3767       24110       24111 AC   0.00000E+00
LA3767       24109       24110      0.12767E-08
CA3768       24115           0      0.94876E-15
RA3768       24115           0      0.41938E+09
RA3769       24114       24115      0.53870E-02
VA3769       24113       24114 AC   0.00000E+00
LA3769       24112       24113      0.12767E-08
CA3770       24118           0      0.94876E-15
RA3770       24118           0      0.41938E+09
RA3771       24117       24118      0.53870E-02
VA3771       24116       24117 AC   0.00000E+00
LA3771       24115       24116      0.12767E-08
CA3772       24121           0      0.94876E-15
RA3772       24121           0      0.41938E+09
RA3773       24120       24121      0.53870E-02
VA3773       24119       24120 AC   0.00000E+00
LA3773       24118       24119      0.12767E-08
CA3774       24124           0      0.94876E-15
RA3774       24124           0      0.41938E+09
RA3775       24123       24124      0.53870E-02
VA3775       24122       24123 AC   0.00000E+00
LA3775       24121       24122      0.12767E-08
CA3776       24127           0      0.94876E-15
RA3776       24127           0      0.41938E+09
RA3777       24126       24127      0.53870E-02
VA3777       24125       24126 AC   0.00000E+00
LA3777       24124       24125      0.12767E-08
CA3778       24130           0      0.16377E-14
RA3778       24130           0      0.41938E+09
RA3779       24129       24130      0.53870E-02
VA3779       24128       24129 AC   0.00000E+00
LA3779       24127       24128      0.12767E-08
RA3780           0       24131      0.26935E-02
VA3780       24131       24132 AC   0.00000E+00
LA3780       24132       24133      0.63835E-09
CA3781       24133           0      0.94876E-15
RA3781       24133           0      0.41938E+09
CA3782       24136           0      0.94876E-15
RA3782       24136           0      0.41938E+09
RA3783       24135       24136      0.53870E-02
VA3783       24134       24135 AC   0.00000E+00
LA3783       24133       24134      0.12767E-08
CA3784       24139           0      0.94876E-15
RA3784       24139           0      0.41938E+09
RA3785       24138       24139      0.53870E-02
VA3785       24137       24138 AC   0.00000E+00
LA3785       24136       24137      0.12767E-08
CA3786       24142           0      0.94876E-15
RA3786       24142           0      0.41938E+09
RA3787       24141       24142      0.53870E-02
VA3787       24140       24141 AC   0.00000E+00
LA3787       24139       24140      0.12767E-08
CA3788       24145           0      0.94876E-15
RA3788       24145           0      0.41938E+09
RA3789       24144       24145      0.53870E-02
VA3789       24143       24144 AC   0.00000E+00
LA3789       24142       24143      0.12767E-08
CA3790       24148           0      0.94876E-15
RA3790       24148           0      0.41938E+09
RA3791       24147       24148      0.53870E-02
VA3791       24146       24147 AC   0.00000E+00
LA3791       24145       24146      0.12767E-08
CA3792       24151           0      0.94876E-15
RA3792       24151           0      0.41938E+09
RA3793       24150       24151      0.53870E-02
VA3793       24149       24150 AC   0.00000E+00
LA3793       24148       24149      0.12767E-08
CA3794       24154           0      0.94876E-15
RA3794       24154           0      0.41938E+09
RA3795       24153       24154      0.53870E-02
VA3795       24152       24153 AC   0.00000E+00
LA3795       24151       24152      0.12767E-08
CA3796       24157           0      0.94876E-15
RA3796       24157           0      0.41938E+09
RA3797       24156       24157      0.53870E-02
VA3797       24155       24156 AC   0.00000E+00
LA3797       24154       24155      0.12767E-08
CA3798       24160           0      0.94876E-15
RA3798       24160           0      0.41938E+09
RA3799       24159       24160      0.53870E-02
VA3799       24158       24159 AC   0.00000E+00
LA3799       24157       24158      0.12767E-08
CA3800       24163           0      0.94876E-15
RA3800       24163           0      0.41938E+09
RA3801       24162       24163      0.53870E-02
VA3801       24161       24162 AC   0.00000E+00
LA3801       24160       24161      0.12767E-08
CA3802       24166           0      0.94876E-15
RA3802       24166           0      0.41938E+09
RA3803       24165       24166      0.53870E-02
VA3803       24164       24165 AC   0.00000E+00
LA3803       24163       24164      0.12767E-08
CA3804       24169           0      0.94876E-15
RA3804       24169           0      0.41938E+09
RA3805       24168       24169      0.53870E-02
VA3805       24167       24168 AC   0.00000E+00
LA3805       24166       24167      0.12767E-08
CA3806       24172           0      0.94876E-15
RA3806       24172           0      0.41938E+09
RA3807       24171       24172      0.53870E-02
VA3807       24170       24171 AC   0.00000E+00
LA3807       24169       24170      0.12767E-08
CA3808       24175           0      0.94876E-15
RA3808       24175           0      0.41938E+09
RA3809       24174       24175      0.53870E-02
VA3809       24173       24174 AC   0.00000E+00
LA3809       24172       24173      0.12767E-08
CA3810       24178           0      0.94876E-15
RA3810       24178           0      0.41938E+09
RA3811       24177       24178      0.53870E-02
VA3811       24176       24177 AC   0.00000E+00
LA3811       24175       24176      0.12767E-08
CA3812       24181           0      0.94876E-15
RA3812       24181           0      0.41938E+09
RA3813       24180       24181      0.53870E-02
VA3813       24179       24180 AC   0.00000E+00
LA3813       24178       24179      0.12767E-08
CA3814       24184           0      0.94876E-15
RA3814       24184           0      0.41938E+09
RA3815       24183       24184      0.53870E-02
VA3815       24182       24183 AC   0.00000E+00
LA3815       24181       24182      0.12767E-08
CA3816       24187           0      0.94876E-15
RA3816       24187           0      0.41938E+09
RA3817       24186       24187      0.53870E-02
VA3817       24185       24186 AC   0.00000E+00
LA3817       24184       24185      0.12767E-08
CA3818       24190           0      0.51451E-14
RA3818       24190           0      0.41938E+09
RA3819       24189       24190      0.53870E-02
VA3819       24188       24189 AC   0.00000E+00
LA3819       24187       24188      0.12767E-08
CA3820       24191           0      0.50868E-14
RA3820       24191           0      0.41938E+09
CA3821       24194           0      0.94876E-15
RA3821       24194           0      0.41938E+09
RA3822       24193       24194      0.53870E-02
VA3822       24192       24193 AC   0.00000E+00
LA3822       24191       24192      0.12767E-08
CA3823       24197           0      0.94876E-15
RA3823       24197           0      0.41938E+09
RA3824       24196       24197      0.53870E-02
VA3824       24195       24196 AC   0.00000E+00
LA3824       24194       24195      0.12767E-08
CA3825       24200           0      0.94876E-15
RA3825       24200           0      0.41938E+09
RA3826       24199       24200      0.53870E-02
VA3826       24198       24199 AC   0.00000E+00
LA3826       24197       24198      0.12767E-08
CA3827       24203           0      0.94876E-15
RA3827       24203           0      0.41938E+09
RA3828       24202       24203      0.53870E-02
VA3828       24201       24202 AC   0.00000E+00
LA3828       24200       24201      0.12767E-08
CA3829       24206           0      0.94876E-15
RA3829       24206           0      0.41938E+09
RA3830       24205       24206      0.53870E-02
VA3830       24204       24205 AC   0.00000E+00
LA3830       24203       24204      0.12767E-08
CA3831       24209           0      0.94876E-15
RA3831       24209           0      0.41938E+09
RA3832       24208       24209      0.53870E-02
VA3832       24207       24208 AC   0.00000E+00
LA3832       24206       24207      0.12767E-08
CA3833       24212           0      0.94876E-15
RA3833       24212           0      0.41938E+09
RA3834       24211       24212      0.53870E-02
VA3834       24210       24211 AC   0.00000E+00
LA3834       24209       24210      0.12767E-08
CA3835       24215           0      0.94876E-15
RA3835       24215           0      0.41938E+09
RA3836       24214       24215      0.53870E-02
VA3836       24213       24214 AC   0.00000E+00
LA3836       24212       24213      0.12767E-08
CA3837       24218           0      0.94876E-15
RA3837       24218           0      0.41938E+09
RA3838       24217       24218      0.53870E-02
VA3838       24216       24217 AC   0.00000E+00
LA3838       24215       24216      0.12767E-08
CA3839       24221           0      0.94876E-15
RA3839       24221           0      0.41938E+09
RA3840       24220       24221      0.53870E-02
VA3840       24219       24220 AC   0.00000E+00
LA3840       24218       24219      0.12767E-08
CA3841       24224           0      0.94876E-15
RA3841       24224           0      0.41938E+09
RA3842       24223       24224      0.53870E-02
VA3842       24222       24223 AC   0.00000E+00
LA3842       24221       24222      0.12767E-08
CA3843       24227           0      0.94876E-15
RA3843       24227           0      0.41938E+09
RA3844       24226       24227      0.53870E-02
VA3844       24225       24226 AC   0.00000E+00
LA3844       24224       24225      0.12767E-08
CA3845       24230           0      0.16377E-14
RA3845       24230           0      0.41938E+09
RA3846       24229       24230      0.53870E-02
VA3846       24228       24229 AC   0.00000E+00
LA3846       24227       24228      0.12767E-08
RA3847           0       24231      0.26935E-02
VA3847       24231       24232 AC   0.00000E+00
LA3847       24232       24233      0.63835E-09
CA3848       24233           0      0.94876E-15
RA3848       24233           0      0.41938E+09
CA3849       24236           0      0.94876E-15
RA3849       24236           0      0.41938E+09
RA3850       24235       24236      0.53870E-02
VA3850       24234       24235 AC   0.00000E+00
LA3850       24233       24234      0.12767E-08
CA3851       24239           0      0.94876E-15
RA3851       24239           0      0.41938E+09
RA3852       24238       24239      0.53870E-02
VA3852       24237       24238 AC   0.00000E+00
LA3852       24236       24237      0.12767E-08
CA3853       24242           0      0.94876E-15
RA3853       24242           0      0.41938E+09
RA3854       24241       24242      0.53870E-02
VA3854       24240       24241 AC   0.00000E+00
LA3854       24239       24240      0.12767E-08
CA3855       24245           0      0.94876E-15
RA3855       24245           0      0.41938E+09
RA3856       24244       24245      0.53870E-02
VA3856       24243       24244 AC   0.00000E+00
LA3856       24242       24243      0.12767E-08
CA3857       24248           0      0.94876E-15
RA3857       24248           0      0.41938E+09
RA3858       24247       24248      0.53870E-02
VA3858       24246       24247 AC   0.00000E+00
LA3858       24245       24246      0.12767E-08
CA3859       24251           0      0.94876E-15
RA3859       24251           0      0.41938E+09
RA3860       24250       24251      0.53870E-02
VA3860       24249       24250 AC   0.00000E+00
LA3860       24248       24249      0.12767E-08
CA3861       24254           0      0.94876E-15
RA3861       24254           0      0.41938E+09
RA3862       24253       24254      0.53870E-02
VA3862       24252       24253 AC   0.00000E+00
LA3862       24251       24252      0.12767E-08
CA3863       24257           0      0.94876E-15
RA3863       24257           0      0.41938E+09
RA3864       24256       24257      0.53870E-02
VA3864       24255       24256 AC   0.00000E+00
LA3864       24254       24255      0.12767E-08
CA3865       24260           0      0.94876E-15
RA3865       24260           0      0.41938E+09
RA3866       24259       24260      0.53870E-02
VA3866       24258       24259 AC   0.00000E+00
LA3866       24257       24258      0.12767E-08
CA3867       24263           0      0.94876E-15
RA3867       24263           0      0.41938E+09
RA3868       24262       24263      0.53870E-02
VA3868       24261       24262 AC   0.00000E+00
LA3868       24260       24261      0.12767E-08
CA3869       24266           0      0.94876E-15
RA3869       24266           0      0.41938E+09
RA3870       24265       24266      0.53870E-02
VA3870       24264       24265 AC   0.00000E+00
LA3870       24263       24264      0.12767E-08
CA3871       24269           0      0.94876E-15
RA3871       24269           0      0.41938E+09
RA3872       24268       24269      0.53870E-02
VA3872       24267       24268 AC   0.00000E+00
LA3872       24266       24267      0.12767E-08
CA3873       24272           0      0.94876E-15
RA3873       24272           0      0.41938E+09
RA3874       24271       24272      0.53870E-02
VA3874       24270       24271 AC   0.00000E+00
LA3874       24269       24270      0.12767E-08
CA3875       24275           0      0.94876E-15
RA3875       24275           0      0.41938E+09
RA3876       24274       24275      0.53870E-02
VA3876       24273       24274 AC   0.00000E+00
LA3876       24272       24273      0.12767E-08
CA3877       24278           0      0.94876E-15
RA3877       24278           0      0.41938E+09
RA3878       24277       24278      0.53870E-02
VA3878       24276       24277 AC   0.00000E+00
LA3878       24275       24276      0.12767E-08
CA3879       24281           0      0.94876E-15
RA3879       24281           0      0.41938E+09
RA3880       24280       24281      0.53870E-02
VA3880       24279       24280 AC   0.00000E+00
LA3880       24278       24279      0.12767E-08
CA3881       24284           0      0.94876E-15
RA3881       24284           0      0.41938E+09
RA3882       24283       24284      0.53870E-02
VA3882       24282       24283 AC   0.00000E+00
LA3882       24281       24282      0.12767E-08
CA3883       24287           0      0.94876E-15
RA3883       24287           0      0.41938E+09
RA3884       24286       24287      0.53870E-02
VA3884       24285       24286 AC   0.00000E+00
LA3884       24284       24285      0.12767E-08
CA3885       24290           0      0.51451E-14
RA3885       24290           0      0.41938E+09
RA3886       24289       24290      0.53870E-02
VA3886       24288       24289 AC   0.00000E+00
LA3886       24287       24288      0.12767E-08
CA3887       24291           0      0.50868E-14
RA3887       24291           0      0.41938E+09
CA3888       24294           0      0.94876E-15
RA3888       24294           0      0.41938E+09
RA3889       24293       24294      0.53870E-02
VA3889       24292       24293 AC   0.00000E+00
LA3889       24291       24292      0.12767E-08
CA3890       24297           0      0.94876E-15
RA3890       24297           0      0.41938E+09
RA3891       24296       24297      0.53870E-02
VA3891       24295       24296 AC   0.00000E+00
LA3891       24294       24295      0.12767E-08
CA3892       24300           0      0.94876E-15
RA3892       24300           0      0.41938E+09
RA3893       24299       24300      0.53870E-02
VA3893       24298       24299 AC   0.00000E+00
LA3893       24297       24298      0.12767E-08
CA3894       24303           0      0.94876E-15
RA3894       24303           0      0.41938E+09
RA3895       24302       24303      0.53870E-02
VA3895       24301       24302 AC   0.00000E+00
LA3895       24300       24301      0.12767E-08
CA3896       24306           0      0.94876E-15
RA3896       24306           0      0.41938E+09
RA3897       24305       24306      0.53870E-02
VA3897       24304       24305 AC   0.00000E+00
LA3897       24303       24304      0.12767E-08
CA3898       24309           0      0.94876E-15
RA3898       24309           0      0.41938E+09
RA3899       24308       24309      0.53870E-02
VA3899       24307       24308 AC   0.00000E+00
LA3899       24306       24307      0.12767E-08
CA3900       24312           0      0.94876E-15
RA3900       24312           0      0.41938E+09
RA3901       24311       24312      0.53870E-02
VA3901       24310       24311 AC   0.00000E+00
LA3901       24309       24310      0.12767E-08
CA3902       24315           0      0.94876E-15
RA3902       24315           0      0.41938E+09
RA3903       24314       24315      0.53870E-02
VA3903       24313       24314 AC   0.00000E+00
LA3903       24312       24313      0.12767E-08
CA3904       24318           0      0.94876E-15
RA3904       24318           0      0.41938E+09
RA3905       24317       24318      0.53870E-02
VA3905       24316       24317 AC   0.00000E+00
LA3905       24315       24316      0.12767E-08
CA3906       24321           0      0.94876E-15
RA3906       24321           0      0.41938E+09
RA3907       24320       24321      0.53870E-02
VA3907       24319       24320 AC   0.00000E+00
LA3907       24318       24319      0.12767E-08
CA3908       24324           0      0.94876E-15
RA3908       24324           0      0.41938E+09
RA3909       24323       24324      0.53870E-02
VA3909       24322       24323 AC   0.00000E+00
LA3909       24321       24322      0.12767E-08
CA3910       24327           0      0.94876E-15
RA3910       24327           0      0.41938E+09
RA3911       24326       24327      0.53870E-02
VA3911       24325       24326 AC   0.00000E+00
LA3911       24324       24325      0.12767E-08
CA3912       24330           0      0.16377E-14
RA3912       24330           0      0.41938E+09
RA3913       24329       24330      0.53870E-02
VA3913       24328       24329 AC   0.00000E+00
LA3913       24327       24328      0.12767E-08
RA3914           0       24331      0.26935E-02
VA3914       24331       24332 AC   0.00000E+00
LA3914       24332       24333      0.63835E-09
CA3915       24333           0      0.94876E-15
RA3915       24333           0      0.41938E+09
CA3916       24336           0      0.94876E-15
RA3916       24336           0      0.41938E+09
RA3917       24335       24336      0.53870E-02
VA3917       24334       24335 AC   0.00000E+00
LA3917       24333       24334      0.12767E-08
CA3918       24339           0      0.94876E-15
RA3918       24339           0      0.41938E+09
RA3919       24338       24339      0.53870E-02
VA3919       24337       24338 AC   0.00000E+00
LA3919       24336       24337      0.12767E-08
CA3920       24342           0      0.94876E-15
RA3920       24342           0      0.41938E+09
RA3921       24341       24342      0.53870E-02
VA3921       24340       24341 AC   0.00000E+00
LA3921       24339       24340      0.12767E-08
CA3922       24345           0      0.94876E-15
RA3922       24345           0      0.41938E+09
RA3923       24344       24345      0.53870E-02
VA3923       24343       24344 AC   0.00000E+00
LA3923       24342       24343      0.12767E-08
CA3924       24348           0      0.94876E-15
RA3924       24348           0      0.41938E+09
RA3925       24347       24348      0.53870E-02
VA3925       24346       24347 AC   0.00000E+00
LA3925       24345       24346      0.12767E-08
CA3926       24351           0      0.94876E-15
RA3926       24351           0      0.41938E+09
RA3927       24350       24351      0.53870E-02
VA3927       24349       24350 AC   0.00000E+00
LA3927       24348       24349      0.12767E-08
CA3928       24354           0      0.94876E-15
RA3928       24354           0      0.41938E+09
RA3929       24353       24354      0.53870E-02
VA3929       24352       24353 AC   0.00000E+00
LA3929       24351       24352      0.12767E-08
CA3930       24357           0      0.94876E-15
RA3930       24357           0      0.41938E+09
RA3931       24356       24357      0.53870E-02
VA3931       24355       24356 AC   0.00000E+00
LA3931       24354       24355      0.12767E-08
CA3932       24360           0      0.94876E-15
RA3932       24360           0      0.41938E+09
RA3933       24359       24360      0.53870E-02
VA3933       24358       24359 AC   0.00000E+00
LA3933       24357       24358      0.12767E-08
CA3934       24363           0      0.94876E-15
RA3934       24363           0      0.41938E+09
RA3935       24362       24363      0.53870E-02
VA3935       24361       24362 AC   0.00000E+00
LA3935       24360       24361      0.12767E-08
CA3936       24366           0      0.94876E-15
RA3936       24366           0      0.41938E+09
RA3937       24365       24366      0.53870E-02
VA3937       24364       24365 AC   0.00000E+00
LA3937       24363       24364      0.12767E-08
CA3938       24369           0      0.94876E-15
RA3938       24369           0      0.41938E+09
RA3939       24368       24369      0.53870E-02
VA3939       24367       24368 AC   0.00000E+00
LA3939       24366       24367      0.12767E-08
CA3940       24372           0      0.94876E-15
RA3940       24372           0      0.41938E+09
RA3941       24371       24372      0.53870E-02
VA3941       24370       24371 AC   0.00000E+00
LA3941       24369       24370      0.12767E-08
CA3942       24375           0      0.94876E-15
RA3942       24375           0      0.41938E+09
RA3943       24374       24375      0.53870E-02
VA3943       24373       24374 AC   0.00000E+00
LA3943       24372       24373      0.12767E-08
CA3944       24378           0      0.94876E-15
RA3944       24378           0      0.41938E+09
RA3945       24377       24378      0.53870E-02
VA3945       24376       24377 AC   0.00000E+00
LA3945       24375       24376      0.12767E-08
CA3946       24381           0      0.94876E-15
RA3946       24381           0      0.41938E+09
RA3947       24380       24381      0.53870E-02
VA3947       24379       24380 AC   0.00000E+00
LA3947       24378       24379      0.12767E-08
CA3948       24384           0      0.94876E-15
RA3948       24384           0      0.41938E+09
RA3949       24383       24384      0.53870E-02
VA3949       24382       24383 AC   0.00000E+00
LA3949       24381       24382      0.12767E-08
CA3950       24387           0      0.94876E-15
RA3950       24387           0      0.41938E+09
RA3951       24386       24387      0.53870E-02
VA3951       24385       24386 AC   0.00000E+00
LA3951       24384       24385      0.12767E-08
CA3952       24390           0      0.51451E-14
RA3952       24390           0      0.41938E+09
RA3953       24389       24390      0.53870E-02
VA3953       24388       24389 AC   0.00000E+00
LA3953       24387       24388      0.12767E-08
CA3954       24391           0      0.50868E-14
RA3954       24391           0      0.41938E+09
CA3955       24394           0      0.94876E-15
RA3955       24394           0      0.41938E+09
RA3956       24393       24394      0.53870E-02
VA3956       24392       24393 AC   0.00000E+00
LA3956       24391       24392      0.12767E-08
CA3957       24397           0      0.94876E-15
RA3957       24397           0      0.41938E+09
RA3958       24396       24397      0.53870E-02
VA3958       24395       24396 AC   0.00000E+00
LA3958       24394       24395      0.12767E-08
CA3959       24400           0      0.94876E-15
RA3959       24400           0      0.41938E+09
RA3960       24399       24400      0.53870E-02
VA3960       24398       24399 AC   0.00000E+00
LA3960       24397       24398      0.12767E-08
CA3961       24403           0      0.94876E-15
RA3961       24403           0      0.41938E+09
RA3962       24402       24403      0.53870E-02
VA3962       24401       24402 AC   0.00000E+00
LA3962       24400       24401      0.12767E-08
CA3963       24406           0      0.94876E-15
RA3963       24406           0      0.41938E+09
RA3964       24405       24406      0.53870E-02
VA3964       24404       24405 AC   0.00000E+00
LA3964       24403       24404      0.12767E-08
CA3965       24409           0      0.94876E-15
RA3965       24409           0      0.41938E+09
RA3966       24408       24409      0.53870E-02
VA3966       24407       24408 AC   0.00000E+00
LA3966       24406       24407      0.12767E-08
CA3967       24412           0      0.94876E-15
RA3967       24412           0      0.41938E+09
RA3968       24411       24412      0.53870E-02
VA3968       24410       24411 AC   0.00000E+00
LA3968       24409       24410      0.12767E-08
CA3969       24415           0      0.94876E-15
RA3969       24415           0      0.41938E+09
RA3970       24414       24415      0.53870E-02
VA3970       24413       24414 AC   0.00000E+00
LA3970       24412       24413      0.12767E-08
CA3971       24418           0      0.94876E-15
RA3971       24418           0      0.41938E+09
RA3972       24417       24418      0.53870E-02
VA3972       24416       24417 AC   0.00000E+00
LA3972       24415       24416      0.12767E-08
CA3973       24421           0      0.94876E-15
RA3973       24421           0      0.41938E+09
RA3974       24420       24421      0.53870E-02
VA3974       24419       24420 AC   0.00000E+00
LA3974       24418       24419      0.12767E-08
CA3975       24424           0      0.94876E-15
RA3975       24424           0      0.41938E+09
RA3976       24423       24424      0.53870E-02
VA3976       24422       24423 AC   0.00000E+00
LA3976       24421       24422      0.12767E-08
CA3977       24427           0      0.94876E-15
RA3977       24427           0      0.41938E+09
RA3978       24426       24427      0.53870E-02
VA3978       24425       24426 AC   0.00000E+00
LA3978       24424       24425      0.12767E-08
CA3979       24430           0      0.16377E-14
RA3979       24430           0      0.41938E+09
RA3980       24429       24430      0.53870E-02
VA3980       24428       24429 AC   0.00000E+00
LA3980       24427       24428      0.12767E-08
RA3981           0       24431      0.26935E-02
VA3981       24431       24432 AC   0.00000E+00
LA3981       24432       24433      0.63835E-09
CA3982       24433           0      0.94876E-15
RA3982       24433           0      0.41938E+09
CA3983       24436           0      0.94876E-15
RA3983       24436           0      0.41938E+09
RA3984       24435       24436      0.53870E-02
VA3984       24434       24435 AC   0.00000E+00
LA3984       24433       24434      0.12767E-08
CA3985       24439           0      0.94876E-15
RA3985       24439           0      0.41938E+09
RA3986       24438       24439      0.53870E-02
VA3986       24437       24438 AC   0.00000E+00
LA3986       24436       24437      0.12767E-08
CA3987       24442           0      0.94876E-15
RA3987       24442           0      0.41938E+09
RA3988       24441       24442      0.53870E-02
VA3988       24440       24441 AC   0.00000E+00
LA3988       24439       24440      0.12767E-08
CA3989       24445           0      0.94876E-15
RA3989       24445           0      0.41938E+09
RA3990       24444       24445      0.53870E-02
VA3990       24443       24444 AC   0.00000E+00
LA3990       24442       24443      0.12767E-08
CA3991       24448           0      0.94876E-15
RA3991       24448           0      0.41938E+09
RA3992       24447       24448      0.53870E-02
VA3992       24446       24447 AC   0.00000E+00
LA3992       24445       24446      0.12767E-08
CA3993       24451           0      0.94876E-15
RA3993       24451           0      0.41938E+09
RA3994       24450       24451      0.53870E-02
VA3994       24449       24450 AC   0.00000E+00
LA3994       24448       24449      0.12767E-08
CA3995       24454           0      0.94876E-15
RA3995       24454           0      0.41938E+09
RA3996       24453       24454      0.53870E-02
VA3996       24452       24453 AC   0.00000E+00
LA3996       24451       24452      0.12767E-08
CA3997       24457           0      0.94876E-15
RA3997       24457           0      0.41938E+09
RA3998       24456       24457      0.53870E-02
VA3998       24455       24456 AC   0.00000E+00
LA3998       24454       24455      0.12767E-08
CA3999       24460           0      0.94876E-15
RA3999       24460           0      0.41938E+09
RA4000       24459       24460      0.53870E-02
VA4000       24458       24459 AC   0.00000E+00
LA4000       24457       24458      0.12767E-08
CA4001       24463           0      0.94876E-15
RA4001       24463           0      0.41938E+09
RA4002       24462       24463      0.53870E-02
VA4002       24461       24462 AC   0.00000E+00
LA4002       24460       24461      0.12767E-08
CA4003       24466           0      0.94876E-15
RA4003       24466           0      0.41938E+09
RA4004       24465       24466      0.53870E-02
VA4004       24464       24465 AC   0.00000E+00
LA4004       24463       24464      0.12767E-08
CA4005       24469           0      0.94876E-15
RA4005       24469           0      0.41938E+09
RA4006       24468       24469      0.53870E-02
VA4006       24467       24468 AC   0.00000E+00
LA4006       24466       24467      0.12767E-08
CA4007       24472           0      0.94876E-15
RA4007       24472           0      0.41938E+09
RA4008       24471       24472      0.53870E-02
VA4008       24470       24471 AC   0.00000E+00
LA4008       24469       24470      0.12767E-08
CA4009       24475           0      0.94876E-15
RA4009       24475           0      0.41938E+09
RA4010       24474       24475      0.53870E-02
VA4010       24473       24474 AC   0.00000E+00
LA4010       24472       24473      0.12767E-08
CA4011       24478           0      0.94876E-15
RA4011       24478           0      0.41938E+09
RA4012       24477       24478      0.53870E-02
VA4012       24476       24477 AC   0.00000E+00
LA4012       24475       24476      0.12767E-08
CA4013       24481           0      0.94876E-15
RA4013       24481           0      0.41938E+09
RA4014       24480       24481      0.53870E-02
VA4014       24479       24480 AC   0.00000E+00
LA4014       24478       24479      0.12767E-08
CA4015       24484           0      0.94876E-15
RA4015       24484           0      0.41938E+09
RA4016       24483       24484      0.53870E-02
VA4016       24482       24483 AC   0.00000E+00
LA4016       24481       24482      0.12767E-08
CA4017       24487           0      0.94876E-15
RA4017       24487           0      0.41938E+09
RA4018       24486       24487      0.53870E-02
VA4018       24485       24486 AC   0.00000E+00
LA4018       24484       24485      0.12767E-08
CA4019       24490           0      0.51451E-14
RA4019       24490           0      0.41938E+09
RA4020       24489       24490      0.53870E-02
VA4020       24488       24489 AC   0.00000E+00
LA4020       24487       24488      0.12767E-08
CA4021       24491           0      0.50868E-14
RA4021       24491           0      0.41938E+09
CA4022       24494           0      0.94876E-15
RA4022       24494           0      0.41938E+09
RA4023       24493       24494      0.53870E-02
VA4023       24492       24493 AC   0.00000E+00
LA4023       24491       24492      0.12767E-08
CA4024       24497           0      0.94876E-15
RA4024       24497           0      0.41938E+09
RA4025       24496       24497      0.53870E-02
VA4025       24495       24496 AC   0.00000E+00
LA4025       24494       24495      0.12767E-08
CA4026       24500           0      0.94876E-15
RA4026       24500           0      0.41938E+09
RA4027       24499       24500      0.53870E-02
VA4027       24498       24499 AC   0.00000E+00
LA4027       24497       24498      0.12767E-08
CA4028       24503           0      0.94876E-15
RA4028       24503           0      0.41938E+09
RA4029       24502       24503      0.53870E-02
VA4029       24501       24502 AC   0.00000E+00
LA4029       24500       24501      0.12767E-08
CA4030       24506           0      0.94876E-15
RA4030       24506           0      0.41938E+09
RA4031       24505       24506      0.53870E-02
VA4031       24504       24505 AC   0.00000E+00
LA4031       24503       24504      0.12767E-08
CA4032       24509           0      0.94876E-15
RA4032       24509           0      0.41938E+09
RA4033       24508       24509      0.53870E-02
VA4033       24507       24508 AC   0.00000E+00
LA4033       24506       24507      0.12767E-08
CA4034       24512           0      0.94876E-15
RA4034       24512           0      0.41938E+09
RA4035       24511       24512      0.53870E-02
VA4035       24510       24511 AC   0.00000E+00
LA4035       24509       24510      0.12767E-08
CA4036       24515           0      0.94876E-15
RA4036       24515           0      0.41938E+09
RA4037       24514       24515      0.53870E-02
VA4037       24513       24514 AC   0.00000E+00
LA4037       24512       24513      0.12767E-08
CA4038       24518           0      0.94876E-15
RA4038       24518           0      0.41938E+09
RA4039       24517       24518      0.53870E-02
VA4039       24516       24517 AC   0.00000E+00
LA4039       24515       24516      0.12767E-08
CA4040       24521           0      0.94876E-15
RA4040       24521           0      0.41938E+09
RA4041       24520       24521      0.53870E-02
VA4041       24519       24520 AC   0.00000E+00
LA4041       24518       24519      0.12767E-08
CA4042       24524           0      0.94876E-15
RA4042       24524           0      0.41938E+09
RA4043       24523       24524      0.53870E-02
VA4043       24522       24523 AC   0.00000E+00
LA4043       24521       24522      0.12767E-08
CA4044       24527           0      0.94876E-15
RA4044       24527           0      0.41938E+09
RA4045       24526       24527      0.53870E-02
VA4045       24525       24526 AC   0.00000E+00
LA4045       24524       24525      0.12767E-08
CA4046       24530           0      0.16377E-14
RA4046       24530           0      0.41938E+09
RA4047       24529       24530      0.53870E-02
VA4047       24528       24529 AC   0.00000E+00
LA4047       24527       24528      0.12767E-08
RA4048           0       24531      0.26935E-02
VA4048       24531       24532 AC   0.00000E+00
LA4048       24532       24533      0.63835E-09
CA4049       24533           0      0.94876E-15
RA4049       24533           0      0.41938E+09
CA4050       24536           0      0.94876E-15
RA4050       24536           0      0.41938E+09
RA4051       24535       24536      0.53870E-02
VA4051       24534       24535 AC   0.00000E+00
LA4051       24533       24534      0.12767E-08
CA4052       24539           0      0.94876E-15
RA4052       24539           0      0.41938E+09
RA4053       24538       24539      0.53870E-02
VA4053       24537       24538 AC   0.00000E+00
LA4053       24536       24537      0.12767E-08
CA4054       24542           0      0.94876E-15
RA4054       24542           0      0.41938E+09
RA4055       24541       24542      0.53870E-02
VA4055       24540       24541 AC   0.00000E+00
LA4055       24539       24540      0.12767E-08
CA4056       24545           0      0.94876E-15
RA4056       24545           0      0.41938E+09
RA4057       24544       24545      0.53870E-02
VA4057       24543       24544 AC   0.00000E+00
LA4057       24542       24543      0.12767E-08
CA4058       24548           0      0.94876E-15
RA4058       24548           0      0.41938E+09
RA4059       24547       24548      0.53870E-02
VA4059       24546       24547 AC   0.00000E+00
LA4059       24545       24546      0.12767E-08
CA4060       24551           0      0.94876E-15
RA4060       24551           0      0.41938E+09
RA4061       24550       24551      0.53870E-02
VA4061       24549       24550 AC   0.00000E+00
LA4061       24548       24549      0.12767E-08
CA4062       24554           0      0.94876E-15
RA4062       24554           0      0.41938E+09
RA4063       24553       24554      0.53870E-02
VA4063       24552       24553 AC   0.00000E+00
LA4063       24551       24552      0.12767E-08
CA4064       24557           0      0.94876E-15
RA4064       24557           0      0.41938E+09
RA4065       24556       24557      0.53870E-02
VA4065       24555       24556 AC   0.00000E+00
LA4065       24554       24555      0.12767E-08
CA4066       24560           0      0.94876E-15
RA4066       24560           0      0.41938E+09
RA4067       24559       24560      0.53870E-02
VA4067       24558       24559 AC   0.00000E+00
LA4067       24557       24558      0.12767E-08
CA4068       24563           0      0.94876E-15
RA4068       24563           0      0.41938E+09
RA4069       24562       24563      0.53870E-02
VA4069       24561       24562 AC   0.00000E+00
LA4069       24560       24561      0.12767E-08
CA4070       24566           0      0.94876E-15
RA4070       24566           0      0.41938E+09
RA4071       24565       24566      0.53870E-02
VA4071       24564       24565 AC   0.00000E+00
LA4071       24563       24564      0.12767E-08
CA4072       24569           0      0.94876E-15
RA4072       24569           0      0.41938E+09
RA4073       24568       24569      0.53870E-02
VA4073       24567       24568 AC   0.00000E+00
LA4073       24566       24567      0.12767E-08
CA4074       24572           0      0.94876E-15
RA4074       24572           0      0.41938E+09
RA4075       24571       24572      0.53870E-02
VA4075       24570       24571 AC   0.00000E+00
LA4075       24569       24570      0.12767E-08
CA4076       24575           0      0.94876E-15
RA4076       24575           0      0.41938E+09
RA4077       24574       24575      0.53870E-02
VA4077       24573       24574 AC   0.00000E+00
LA4077       24572       24573      0.12767E-08
CA4078       24578           0      0.94876E-15
RA4078       24578           0      0.41938E+09
RA4079       24577       24578      0.53870E-02
VA4079       24576       24577 AC   0.00000E+00
LA4079       24575       24576      0.12767E-08
CA4080       24581           0      0.94876E-15
RA4080       24581           0      0.41938E+09
RA4081       24580       24581      0.53870E-02
VA4081       24579       24580 AC   0.00000E+00
LA4081       24578       24579      0.12767E-08
CA4082       24584           0      0.94876E-15
RA4082       24584           0      0.41938E+09
RA4083       24583       24584      0.53870E-02
VA4083       24582       24583 AC   0.00000E+00
LA4083       24581       24582      0.12767E-08
CA4084       24587           0      0.94876E-15
RA4084       24587           0      0.41938E+09
RA4085       24586       24587      0.53870E-02
VA4085       24585       24586 AC   0.00000E+00
LA4085       24584       24585      0.12767E-08
CA4086       24590           0      0.51451E-14
RA4086       24590           0      0.41938E+09
RA4087       24589       24590      0.53870E-02
VA4087       24588       24589 AC   0.00000E+00
LA4087       24587       24588      0.12767E-08
CA4088       24591           0      0.50868E-14
RA4088       24591           0      0.41938E+09
CA4089       24594           0      0.94876E-15
RA4089       24594           0      0.41938E+09
RA4090       24593       24594      0.53870E-02
VA4090       24592       24593 AC   0.00000E+00
LA4090       24591       24592      0.12767E-08
CA4091       24597           0      0.94876E-15
RA4091       24597           0      0.41938E+09
RA4092       24596       24597      0.53870E-02
VA4092       24595       24596 AC   0.00000E+00
LA4092       24594       24595      0.12767E-08
CA4093       24600           0      0.94876E-15
RA4093       24600           0      0.41938E+09
RA4094       24599       24600      0.53870E-02
VA4094       24598       24599 AC   0.00000E+00
LA4094       24597       24598      0.12767E-08
CA4095       24603           0      0.94876E-15
RA4095       24603           0      0.41938E+09
RA4096       24602       24603      0.53870E-02
VA4096       24601       24602 AC   0.00000E+00
LA4096       24600       24601      0.12767E-08
CA4097       24606           0      0.94876E-15
RA4097       24606           0      0.41938E+09
RA4098       24605       24606      0.53870E-02
VA4098       24604       24605 AC   0.00000E+00
LA4098       24603       24604      0.12767E-08
CA4099       24609           0      0.94876E-15
RA4099       24609           0      0.41938E+09
RA4100       24608       24609      0.53870E-02
VA4100       24607       24608 AC   0.00000E+00
LA4100       24606       24607      0.12767E-08
CA4101       24612           0      0.94876E-15
RA4101       24612           0      0.41938E+09
RA4102       24611       24612      0.53870E-02
VA4102       24610       24611 AC   0.00000E+00
LA4102       24609       24610      0.12767E-08
CA4103       24615           0      0.94876E-15
RA4103       24615           0      0.41938E+09
RA4104       24614       24615      0.53870E-02
VA4104       24613       24614 AC   0.00000E+00
LA4104       24612       24613      0.12767E-08
CA4105       24618           0      0.94876E-15
RA4105       24618           0      0.41938E+09
RA4106       24617       24618      0.53870E-02
VA4106       24616       24617 AC   0.00000E+00
LA4106       24615       24616      0.12767E-08
CA4107       24621           0      0.94876E-15
RA4107       24621           0      0.41938E+09
RA4108       24620       24621      0.53870E-02
VA4108       24619       24620 AC   0.00000E+00
LA4108       24618       24619      0.12767E-08
CA4109       24624           0      0.94876E-15
RA4109       24624           0      0.41938E+09
RA4110       24623       24624      0.53870E-02
VA4110       24622       24623 AC   0.00000E+00
LA4110       24621       24622      0.12767E-08
CA4111       24627           0      0.94876E-15
RA4111       24627           0      0.41938E+09
RA4112       24626       24627      0.53870E-02
VA4112       24625       24626 AC   0.00000E+00
LA4112       24624       24625      0.12767E-08
CA4113       24630           0      0.16377E-14
RA4113       24630           0      0.41938E+09
RA4114       24629       24630      0.53870E-02
VA4114       24628       24629 AC   0.00000E+00
LA4114       24627       24628      0.12767E-08
RA4115           0       24631      0.26935E-02
VA4115       24631       24632 AC   0.00000E+00
LA4115       24632       24633      0.63835E-09
CA4116       24633           0      0.94876E-15
RA4116       24633           0      0.41938E+09
CA4117       24636           0      0.94876E-15
RA4117       24636           0      0.41938E+09
RA4118       24635       24636      0.53870E-02
VA4118       24634       24635 AC   0.00000E+00
LA4118       24633       24634      0.12767E-08
CA4119       24639           0      0.94876E-15
RA4119       24639           0      0.41938E+09
RA4120       24638       24639      0.53870E-02
VA4120       24637       24638 AC   0.00000E+00
LA4120       24636       24637      0.12767E-08
CA4121       24642           0      0.94876E-15
RA4121       24642           0      0.41938E+09
RA4122       24641       24642      0.53870E-02
VA4122       24640       24641 AC   0.00000E+00
LA4122       24639       24640      0.12767E-08
CA4123       24645           0      0.94876E-15
RA4123       24645           0      0.41938E+09
RA4124       24644       24645      0.53870E-02
VA4124       24643       24644 AC   0.00000E+00
LA4124       24642       24643      0.12767E-08
CA4125       24648           0      0.94876E-15
RA4125       24648           0      0.41938E+09
RA4126       24647       24648      0.53870E-02
VA4126       24646       24647 AC   0.00000E+00
LA4126       24645       24646      0.12767E-08
CA4127       24651           0      0.94876E-15
RA4127       24651           0      0.41938E+09
RA4128       24650       24651      0.53870E-02
VA4128       24649       24650 AC   0.00000E+00
LA4128       24648       24649      0.12767E-08
CA4129       24654           0      0.94876E-15
RA4129       24654           0      0.41938E+09
RA4130       24653       24654      0.53870E-02
VA4130       24652       24653 AC   0.00000E+00
LA4130       24651       24652      0.12767E-08
CA4131       24657           0      0.94876E-15
RA4131       24657           0      0.41938E+09
RA4132       24656       24657      0.53870E-02
VA4132       24655       24656 AC   0.00000E+00
LA4132       24654       24655      0.12767E-08
CA4133       24660           0      0.94876E-15
RA4133       24660           0      0.41938E+09
RA4134       24659       24660      0.53870E-02
VA4134       24658       24659 AC   0.00000E+00
LA4134       24657       24658      0.12767E-08
CA4135       24663           0      0.94876E-15
RA4135       24663           0      0.41938E+09
RA4136       24662       24663      0.53870E-02
VA4136       24661       24662 AC   0.00000E+00
LA4136       24660       24661      0.12767E-08
CA4137       24666           0      0.94876E-15
RA4137       24666           0      0.41938E+09
RA4138       24665       24666      0.53870E-02
VA4138       24664       24665 AC   0.00000E+00
LA4138       24663       24664      0.12767E-08
CA4139       24669           0      0.94876E-15
RA4139       24669           0      0.41938E+09
RA4140       24668       24669      0.53870E-02
VA4140       24667       24668 AC   0.00000E+00
LA4140       24666       24667      0.12767E-08
CA4141       24672           0      0.94876E-15
RA4141       24672           0      0.41938E+09
RA4142       24671       24672      0.53870E-02
VA4142       24670       24671 AC   0.00000E+00
LA4142       24669       24670      0.12767E-08
CA4143       24675           0      0.94876E-15
RA4143       24675           0      0.41938E+09
RA4144       24674       24675      0.53870E-02
VA4144       24673       24674 AC   0.00000E+00
LA4144       24672       24673      0.12767E-08
CA4145       24678           0      0.94876E-15
RA4145       24678           0      0.41938E+09
RA4146       24677       24678      0.53870E-02
VA4146       24676       24677 AC   0.00000E+00
LA4146       24675       24676      0.12767E-08
CA4147       24681           0      0.94876E-15
RA4147       24681           0      0.41938E+09
RA4148       24680       24681      0.53870E-02
VA4148       24679       24680 AC   0.00000E+00
LA4148       24678       24679      0.12767E-08
CA4149       24684           0      0.94876E-15
RA4149       24684           0      0.41938E+09
RA4150       24683       24684      0.53870E-02
VA4150       24682       24683 AC   0.00000E+00
LA4150       24681       24682      0.12767E-08
CA4151       24687           0      0.94876E-15
RA4151       24687           0      0.41938E+09
RA4152       24686       24687      0.53870E-02
VA4152       24685       24686 AC   0.00000E+00
LA4152       24684       24685      0.12767E-08
CA4153       24690           0      0.94876E-15
RA4153       24690           0      0.41938E+09
RA4154       24689       24690      0.53870E-02
VA4154       24688       24689 AC   0.00000E+00
LA4154       24687       24688      0.12767E-08
CA4155       24693           0      0.49648E-14
RA4155       24693           0      0.41938E+09
RA4156       24692       24693      0.53870E-02
VA4156       24691       24692 AC   0.00000E+00
LA4156       24690       24691      0.71000E-09
CA4157       24696           0      0.49648E-14
RA4157       24696           0      0.41938E+09
RA4158       24695       24696      0.53870E-02
VA4158       24694       24695 AC   0.00000E+00
LA4158       24693       24694      0.14329E-09
CA4159       24699           0      0.49648E-14
RA4159       24699           0      0.41938E+09
RA4160       24698       24699      0.53870E-02
VA4160       24697       24698 AC   0.00000E+00
LA4160       24696       24697      0.14329E-09
CA4161       24702           0      0.49648E-14
RA4161       24702           0      0.41938E+09
RA4162       24701       24702      0.53870E-02
VA4162       24700       24701 AC   0.00000E+00
LA4162       24699       24700      0.14329E-09
CA4163       24705           0      0.49648E-14
RA4163       24705           0      0.41938E+09
RA4164       24704       24705      0.53870E-02
VA4164       24703       24704 AC   0.00000E+00
LA4164       24702       24703      0.14329E-09
CA4165       24708           0      0.49648E-14
RA4165       24708           0      0.41938E+09
RA4166       24707       24708      0.53870E-02
VA4166       24706       24707 AC   0.00000E+00
LA4166       24705       24706      0.14329E-09
CA4167       24711           0      0.49648E-14
RA4167       24711           0      0.41938E+09
RA4168       24710       24711      0.53870E-02
VA4168       24709       24710 AC   0.00000E+00
LA4168       24708       24709      0.14329E-09
CA4169       24714           0      0.49648E-14
RA4169       24714           0      0.41938E+09
RA4170       24713       24714      0.53870E-02
VA4170       24712       24713 AC   0.00000E+00
LA4170       24711       24712      0.14329E-09
CA4171       24717           0      0.49648E-14
RA4171       24717           0      0.41938E+09
RA4172       24716       24717      0.53870E-02
VA4172       24715       24716 AC   0.00000E+00
LA4172       24714       24715      0.14329E-09
CA4173       24720           0      0.49648E-14
RA4173       24720           0      0.41938E+09
RA4174       24719       24720      0.53870E-02
VA4174       24718       24719 AC   0.00000E+00
LA4174       24717       24718      0.14329E-09
CA4175       24723           0      0.49648E-14
RA4175       24723           0      0.41938E+09
RA4176       24722       24723      0.53870E-02
VA4176       24721       24722 AC   0.00000E+00
LA4176       24720       24721      0.14329E-09
CA4177       24726           0      0.49648E-14
RA4177       24726           0      0.41938E+09
RA4178       24725       24726      0.53870E-02
VA4178       24724       24725 AC   0.00000E+00
LA4178       24723       24724      0.14329E-09
CA4179       24729           0      0.94876E-15
RA4179       24729           0      0.41938E+09
RA4180       24728       24729      0.53870E-02
VA4180       24727       24728 AC   0.00000E+00
LA4180       24726       24727      0.71000E-09
CA4181       24732           0      0.94876E-15
RA4181       24732           0      0.41938E+09
RA4182       24731       24732      0.53870E-02
VA4182       24730       24731 AC   0.00000E+00
LA4182       24729       24730      0.12767E-08
CA4183       24735           0      0.94876E-15
RA4183       24735           0      0.41938E+09
RA4184       24734       24735      0.53870E-02
VA4184       24733       24734 AC   0.00000E+00
LA4184       24732       24733      0.12767E-08
CA4185       24738           0      0.94876E-15
RA4185       24738           0      0.41938E+09
RA4186       24737       24738      0.53870E-02
VA4186       24736       24737 AC   0.00000E+00
LA4186       24735       24736      0.12767E-08
CA4187       24741           0      0.94876E-15
RA4187       24741           0      0.41938E+09
RA4188       24740       24741      0.53870E-02
VA4188       24739       24740 AC   0.00000E+00
LA4188       24738       24739      0.12767E-08
CA4189       24744           0      0.94876E-15
RA4189       24744           0      0.41938E+09
RA4190       24743       24744      0.53870E-02
VA4190       24742       24743 AC   0.00000E+00
LA4190       24741       24742      0.12767E-08
CA4191       24747           0      0.94876E-15
RA4191       24747           0      0.41938E+09
RA4192       24746       24747      0.53870E-02
VA4192       24745       24746 AC   0.00000E+00
LA4192       24744       24745      0.12767E-08
CA4193       24750           0      0.94876E-15
RA4193       24750           0      0.41938E+09
RA4194       24749       24750      0.53870E-02
VA4194       24748       24749 AC   0.00000E+00
LA4194       24747       24748      0.12767E-08
CA4195       24753           0      0.94876E-15
RA4195       24753           0      0.41938E+09
RA4196       24752       24753      0.53870E-02
VA4196       24751       24752 AC   0.00000E+00
LA4196       24750       24751      0.12767E-08
CA4197       24756           0      0.94876E-15
RA4197       24756           0      0.41938E+09
RA4198       24755       24756      0.53870E-02
VA4198       24754       24755 AC   0.00000E+00
LA4198       24753       24754      0.12767E-08
CA4199       24759           0      0.94876E-15
RA4199       24759           0      0.41938E+09
RA4200       24758       24759      0.53870E-02
VA4200       24757       24758 AC   0.00000E+00
LA4200       24756       24757      0.12767E-08
CA4201       24762           0      0.94876E-15
RA4201       24762           0      0.41938E+09
RA4202       24761       24762      0.53870E-02
VA4202       24760       24761 AC   0.00000E+00
LA4202       24759       24760      0.12767E-08
CA4203       24765           0      0.94876E-15
RA4203       24765           0      0.41938E+09
RA4204       24764       24765      0.53870E-02
VA4204       24763       24764 AC   0.00000E+00
LA4204       24762       24763      0.12767E-08
CA4205       24768           0      0.18149E-14
RA4205       24768           0      0.41938E+09
RA4206       24767       24768      0.53870E-02
VA4206       24766       24767 AC   0.00000E+00
LA4206       24765       24766      0.12767E-08
RA4207           0       24769      0.26935E-02
VA4207       24769       24770 AC   0.00000E+00
LA4207       24770       24771      0.63835E-09
CA4208       24771           0      0.94876E-15
RA4208       24771           0      0.41938E+09
CA4209       24774           0      0.94876E-15
RA4209       24774           0      0.41938E+09
RA4210       24773       24774      0.53870E-02
VA4210       24772       24773 AC   0.00000E+00
LA4210       24771       24772      0.12767E-08
CA4211       24777           0      0.94876E-15
RA4211       24777           0      0.41938E+09
RA4212       24776       24777      0.53870E-02
VA4212       24775       24776 AC   0.00000E+00
LA4212       24774       24775      0.12767E-08
CA4213       24780           0      0.94876E-15
RA4213       24780           0      0.41938E+09
RA4214       24779       24780      0.53870E-02
VA4214       24778       24779 AC   0.00000E+00
LA4214       24777       24778      0.12767E-08
CA4215       24783           0      0.94876E-15
RA4215       24783           0      0.41938E+09
RA4216       24782       24783      0.53870E-02
VA4216       24781       24782 AC   0.00000E+00
LA4216       24780       24781      0.12767E-08
CA4217       24786           0      0.94876E-15
RA4217       24786           0      0.41938E+09
RA4218       24785       24786      0.53870E-02
VA4218       24784       24785 AC   0.00000E+00
LA4218       24783       24784      0.12767E-08
CA4219       24789           0      0.94876E-15
RA4219       24789           0      0.41938E+09
RA4220       24788       24789      0.53870E-02
VA4220       24787       24788 AC   0.00000E+00
LA4220       24786       24787      0.12767E-08
CA4221       24792           0      0.94876E-15
RA4221       24792           0      0.41938E+09
RA4222       24791       24792      0.53870E-02
VA4222       24790       24791 AC   0.00000E+00
LA4222       24789       24790      0.12767E-08
CA4223       24795           0      0.94876E-15
RA4223       24795           0      0.41938E+09
RA4224       24794       24795      0.53870E-02
VA4224       24793       24794 AC   0.00000E+00
LA4224       24792       24793      0.12767E-08
CA4225       24798           0      0.94876E-15
RA4225       24798           0      0.41938E+09
RA4226       24797       24798      0.53870E-02
VA4226       24796       24797 AC   0.00000E+00
LA4226       24795       24796      0.12767E-08
CA4227       24801           0      0.94876E-15
RA4227       24801           0      0.41938E+09
RA4228       24800       24801      0.53870E-02
VA4228       24799       24800 AC   0.00000E+00
LA4228       24798       24799      0.12767E-08
CA4229       24804           0      0.94876E-15
RA4229       24804           0      0.41938E+09
RA4230       24803       24804      0.53870E-02
VA4230       24802       24803 AC   0.00000E+00
LA4230       24801       24802      0.12767E-08
CA4231       24807           0      0.94876E-15
RA4231       24807           0      0.41938E+09
RA4232       24806       24807      0.53870E-02
VA4232       24805       24806 AC   0.00000E+00
LA4232       24804       24805      0.12767E-08
CA4233       24810           0      0.94876E-15
RA4233       24810           0      0.41938E+09
RA4234       24809       24810      0.53870E-02
VA4234       24808       24809 AC   0.00000E+00
LA4234       24807       24808      0.12767E-08
CA4235       24813           0      0.94876E-15
RA4235       24813           0      0.41938E+09
RA4236       24812       24813      0.53870E-02
VA4236       24811       24812 AC   0.00000E+00
LA4236       24810       24811      0.12767E-08
CA4237       24816           0      0.94876E-15
RA4237       24816           0      0.41938E+09
RA4238       24815       24816      0.53870E-02
VA4238       24814       24815 AC   0.00000E+00
LA4238       24813       24814      0.12767E-08
CA4239       24819           0      0.94876E-15
RA4239       24819           0      0.41938E+09
RA4240       24818       24819      0.53870E-02
VA4240       24817       24818 AC   0.00000E+00
LA4240       24816       24817      0.12767E-08
CA4241       24822           0      0.94876E-15
RA4241       24822           0      0.41938E+09
RA4242       24821       24822      0.53870E-02
VA4242       24820       24821 AC   0.00000E+00
LA4242       24819       24820      0.12767E-08
CA4243       24825           0      0.94876E-15
RA4243       24825           0      0.41938E+09
RA4244       24824       24825      0.53870E-02
VA4244       24823       24824 AC   0.00000E+00
LA4244       24822       24823      0.12767E-08
CA4245       24828           0      0.94876E-15
RA4245       24828           0      0.41938E+09
RA4246       24827       24828      0.53870E-02
VA4246       24826       24827 AC   0.00000E+00
LA4246       24825       24826      0.12767E-08
CA4247       24831           0      0.94876E-15
RA4247       24831           0      0.41938E+09
RA4248       24830       24831      0.53870E-02
VA4248       24829       24830 AC   0.00000E+00
LA4248       24828       24829      0.12767E-08
CA4249       24834           0      0.94876E-15
RA4249       24834           0      0.41938E+09
RA4250       24833       24834      0.53870E-02
VA4250       24832       24833 AC   0.00000E+00
LA4250       24831       24832      0.12767E-08
CA4251       24837           0      0.94876E-15
RA4251       24837           0      0.41938E+09
RA4252       24836       24837      0.53870E-02
VA4252       24835       24836 AC   0.00000E+00
LA4252       24834       24835      0.12767E-08
CA4253       24840           0      0.94876E-15
RA4253       24840           0      0.41938E+09
RA4254       24839       24840      0.53870E-02
VA4254       24838       24839 AC   0.00000E+00
LA4254       24837       24838      0.12767E-08
CA4255       24843           0      0.94876E-15
RA4255       24843           0      0.41938E+09
RA4256       24842       24843      0.53870E-02
VA4256       24841       24842 AC   0.00000E+00
LA4256       24840       24841      0.12767E-08
CA4257       24846           0      0.94876E-15
RA4257       24846           0      0.41938E+09
RA4258       24845       24846      0.53870E-02
VA4258       24844       24845 AC   0.00000E+00
LA4258       24843       24844      0.12767E-08
CA4259       24849           0      0.94876E-15
RA4259       24849           0      0.41938E+09
RA4260       24848       24849      0.53870E-02
VA4260       24847       24848 AC   0.00000E+00
LA4260       24846       24847      0.12767E-08
CA4261       24852           0      0.94876E-15
RA4261       24852           0      0.41938E+09
RA4262       24851       24852      0.53870E-02
VA4262       24850       24851 AC   0.00000E+00
LA4262       24849       24850      0.12767E-08
CA4263       24855           0      0.94876E-15
RA4263       24855           0      0.41938E+09
RA4264       24854       24855      0.53870E-02
VA4264       24853       24854 AC   0.00000E+00
LA4264       24852       24853      0.12767E-08
CA4265       24858           0      0.94876E-15
RA4265       24858           0      0.41938E+09
RA4266       24857       24858      0.53870E-02
VA4266       24856       24857 AC   0.00000E+00
LA4266       24855       24856      0.12767E-08
CA4267       24861           0      0.94876E-15
RA4267       24861           0      0.41938E+09
RA4268       24860       24861      0.53870E-02
VA4268       24859       24860 AC   0.00000E+00
LA4268       24858       24859      0.12767E-08
CA4269       24864           0      0.94876E-15
RA4269       24864           0      0.41938E+09
RA4270       24863       24864      0.53870E-02
VA4270       24862       24863 AC   0.00000E+00
LA4270       24861       24862      0.12767E-08
CA4271       24867           0      0.94876E-15
RA4271       24867           0      0.41938E+09
RA4272       24866       24867      0.53870E-02
VA4272       24865       24866 AC   0.00000E+00
LA4272       24864       24865      0.12767E-08
CA4273       24870           0      0.94876E-15
RA4273       24870           0      0.41938E+09
RA4274       24869       24870      0.53870E-02
VA4274       24868       24869 AC   0.00000E+00
LA4274       24867       24868      0.12767E-08
CA4275       24873           0      0.94876E-15
RA4275       24873           0      0.41938E+09
RA4276       24872       24873      0.53870E-02
VA4276       24871       24872 AC   0.00000E+00
LA4276       24870       24871      0.12767E-08
CA4277       24876           0      0.94876E-15
RA4277       24876           0      0.41938E+09
RA4278       24875       24876      0.53870E-02
VA4278       24874       24875 AC   0.00000E+00
LA4278       24873       24874      0.12767E-08
CA4279       24879           0      0.94876E-15
RA4279       24879           0      0.41938E+09
RA4280       24878       24879      0.53870E-02
VA4280       24877       24878 AC   0.00000E+00
LA4280       24876       24877      0.12767E-08
CA4281       24882           0      0.94876E-15
RA4281       24882           0      0.41938E+09
RA4282       24881       24882      0.53870E-02
VA4282       24880       24881 AC   0.00000E+00
LA4282       24879       24880      0.12767E-08
CA4283       24885           0      0.94876E-15
RA4283       24885           0      0.41938E+09
RA4284       24884       24885      0.53870E-02
VA4284       24883       24884 AC   0.00000E+00
LA4284       24882       24883      0.12767E-08
CA4285       24888           0      0.94876E-15
RA4285       24888           0      0.41938E+09
RA4286       24887       24888      0.53870E-02
VA4286       24886       24887 AC   0.00000E+00
LA4286       24885       24886      0.12767E-08
CA4287       24891           0      0.94876E-15
RA4287       24891           0      0.41938E+09
RA4288       24890       24891      0.53870E-02
VA4288       24889       24890 AC   0.00000E+00
LA4288       24888       24889      0.12767E-08
CA4289       24894           0      0.94876E-15
RA4289       24894           0      0.41938E+09
RA4290       24893       24894      0.53870E-02
VA4290       24892       24893 AC   0.00000E+00
LA4290       24891       24892      0.12767E-08
CA4291       24897           0      0.94876E-15
RA4291       24897           0      0.41938E+09
RA4292       24896       24897      0.53870E-02
VA4292       24895       24896 AC   0.00000E+00
LA4292       24894       24895      0.12767E-08
CA4293       24900           0      0.94876E-15
RA4293       24900           0      0.41938E+09
RA4294       24899       24900      0.53870E-02
VA4294       24898       24899 AC   0.00000E+00
LA4294       24897       24898      0.12767E-08
CA4295       24903           0      0.94876E-15
RA4295       24903           0      0.41938E+09
RA4296       24902       24903      0.53870E-02
VA4296       24901       24902 AC   0.00000E+00
LA4296       24900       24901      0.12767E-08
CA4297       24906           0      0.18149E-14
RA4297       24906           0      0.41938E+09
RA4298       24905       24906      0.53870E-02
VA4298       24904       24905 AC   0.00000E+00
LA4298       24903       24904      0.12767E-08
RA4299           0       24907      0.26935E-02
VA4299       24907       24908 AC   0.00000E+00
LA4299       24908       24909      0.63835E-09
CA4300       24909           0      0.94876E-15
RA4300       24909           0      0.41938E+09
CA4301       24912           0      0.94876E-15
RA4301       24912           0      0.41938E+09
RA4302       24911       24912      0.53870E-02
VA4302       24910       24911 AC   0.00000E+00
LA4302       24909       24910      0.12767E-08
CA4303       24915           0      0.94876E-15
RA4303       24915           0      0.41938E+09
RA4304       24914       24915      0.53870E-02
VA4304       24913       24914 AC   0.00000E+00
LA4304       24912       24913      0.12767E-08
CA4305       24918           0      0.94876E-15
RA4305       24918           0      0.41938E+09
RA4306       24917       24918      0.53870E-02
VA4306       24916       24917 AC   0.00000E+00
LA4306       24915       24916      0.12767E-08
CA4307       24921           0      0.94876E-15
RA4307       24921           0      0.41938E+09
RA4308       24920       24921      0.53870E-02
VA4308       24919       24920 AC   0.00000E+00
LA4308       24918       24919      0.12767E-08
CA4309       24924           0      0.94876E-15
RA4309       24924           0      0.41938E+09
RA4310       24923       24924      0.53870E-02
VA4310       24922       24923 AC   0.00000E+00
LA4310       24921       24922      0.12767E-08
CA4311       24927           0      0.94876E-15
RA4311       24927           0      0.41938E+09
RA4312       24926       24927      0.53870E-02
VA4312       24925       24926 AC   0.00000E+00
LA4312       24924       24925      0.12767E-08
CA4313       24930           0      0.94876E-15
RA4313       24930           0      0.41938E+09
RA4314       24929       24930      0.53870E-02
VA4314       24928       24929 AC   0.00000E+00
LA4314       24927       24928      0.12767E-08
CA4315       24933           0      0.94876E-15
RA4315       24933           0      0.41938E+09
RA4316       24932       24933      0.53870E-02
VA4316       24931       24932 AC   0.00000E+00
LA4316       24930       24931      0.12767E-08
CA4317       24936           0      0.94876E-15
RA4317       24936           0      0.41938E+09
RA4318       24935       24936      0.53870E-02
VA4318       24934       24935 AC   0.00000E+00
LA4318       24933       24934      0.12767E-08
CA4319       24939           0      0.94876E-15
RA4319       24939           0      0.41938E+09
RA4320       24938       24939      0.53870E-02
VA4320       24937       24938 AC   0.00000E+00
LA4320       24936       24937      0.12767E-08
CA4321       24942           0      0.94876E-15
RA4321       24942           0      0.41938E+09
RA4322       24941       24942      0.53870E-02
VA4322       24940       24941 AC   0.00000E+00
LA4322       24939       24940      0.12767E-08
CA4323       24945           0      0.94876E-15
RA4323       24945           0      0.41938E+09
RA4324       24944       24945      0.53870E-02
VA4324       24943       24944 AC   0.00000E+00
LA4324       24942       24943      0.12767E-08
CA4325       24948           0      0.94876E-15
RA4325       24948           0      0.41938E+09
RA4326       24947       24948      0.53870E-02
VA4326       24946       24947 AC   0.00000E+00
LA4326       24945       24946      0.12767E-08
CA4327       24951           0      0.94876E-15
RA4327       24951           0      0.41938E+09
RA4328       24950       24951      0.53870E-02
VA4328       24949       24950 AC   0.00000E+00
LA4328       24948       24949      0.12767E-08
CA4329       24954           0      0.94876E-15
RA4329       24954           0      0.41938E+09
RA4330       24953       24954      0.53870E-02
VA4330       24952       24953 AC   0.00000E+00
LA4330       24951       24952      0.12767E-08
CA4331       24957           0      0.94876E-15
RA4331       24957           0      0.41938E+09
RA4332       24956       24957      0.53870E-02
VA4332       24955       24956 AC   0.00000E+00
LA4332       24954       24955      0.12767E-08
CA4333       24960           0      0.94876E-15
RA4333       24960           0      0.41938E+09
RA4334       24959       24960      0.53870E-02
VA4334       24958       24959 AC   0.00000E+00
LA4334       24957       24958      0.12767E-08
CA4335       24963           0      0.94876E-15
RA4335       24963           0      0.41938E+09
RA4336       24962       24963      0.53870E-02
VA4336       24961       24962 AC   0.00000E+00
LA4336       24960       24961      0.12767E-08
CA4337       24966           0      0.94876E-15
RA4337       24966           0      0.41938E+09
RA4338       24965       24966      0.53870E-02
VA4338       24964       24965 AC   0.00000E+00
LA4338       24963       24964      0.12767E-08
CA4339       24969           0      0.94876E-15
RA4339       24969           0      0.41938E+09
RA4340       24968       24969      0.53870E-02
VA4340       24967       24968 AC   0.00000E+00
LA4340       24966       24967      0.12767E-08
CA4341       24972           0      0.94876E-15
RA4341       24972           0      0.41938E+09
RA4342       24971       24972      0.53870E-02
VA4342       24970       24971 AC   0.00000E+00
LA4342       24969       24970      0.12767E-08
CA4343       24975           0      0.94876E-15
RA4343       24975           0      0.41938E+09
RA4344       24974       24975      0.53870E-02
VA4344       24973       24974 AC   0.00000E+00
LA4344       24972       24973      0.12767E-08
CA4345       24978           0      0.94876E-15
RA4345       24978           0      0.41938E+09
RA4346       24977       24978      0.53870E-02
VA4346       24976       24977 AC   0.00000E+00
LA4346       24975       24976      0.12767E-08
CA4347       24981           0      0.94876E-15
RA4347       24981           0      0.41938E+09
RA4348       24980       24981      0.53870E-02
VA4348       24979       24980 AC   0.00000E+00
LA4348       24978       24979      0.12767E-08
CA4349       24984           0      0.94876E-15
RA4349       24984           0      0.41938E+09
RA4350       24983       24984      0.53870E-02
VA4350       24982       24983 AC   0.00000E+00
LA4350       24981       24982      0.12767E-08
CA4351       24987           0      0.94876E-15
RA4351       24987           0      0.41938E+09
RA4352       24986       24987      0.53870E-02
VA4352       24985       24986 AC   0.00000E+00
LA4352       24984       24985      0.12767E-08
CA4353       24990           0      0.94876E-15
RA4353       24990           0      0.41938E+09
RA4354       24989       24990      0.53870E-02
VA4354       24988       24989 AC   0.00000E+00
LA4354       24987       24988      0.12767E-08
CA4355       24993           0      0.94876E-15
RA4355       24993           0      0.41938E+09
RA4356       24992       24993      0.53870E-02
VA4356       24991       24992 AC   0.00000E+00
LA4356       24990       24991      0.12767E-08
CA4357       24996           0      0.94876E-15
RA4357       24996           0      0.41938E+09
RA4358       24995       24996      0.53870E-02
VA4358       24994       24995 AC   0.00000E+00
LA4358       24993       24994      0.12767E-08
CA4359       24999           0      0.94876E-15
RA4359       24999           0      0.41938E+09
RA4360       24998       24999      0.53870E-02
VA4360       24997       24998 AC   0.00000E+00
LA4360       24996       24997      0.12767E-08
CA4361       25002           0      0.94876E-15
RA4361       25002           0      0.41938E+09
RA4362       25001       25002      0.53870E-02
VA4362       25000       25001 AC   0.00000E+00
LA4362       24999       25000      0.12767E-08
CA4363       25005           0      0.94876E-15
RA4363       25005           0      0.41938E+09
RA4364       25004       25005      0.53870E-02
VA4364       25003       25004 AC   0.00000E+00
LA4364       25002       25003      0.12767E-08
CA4365       25008           0      0.94876E-15
RA4365       25008           0      0.41938E+09
RA4366       25007       25008      0.53870E-02
VA4366       25006       25007 AC   0.00000E+00
LA4366       25005       25006      0.12767E-08
CA4367       25011           0      0.94876E-15
RA4367       25011           0      0.41938E+09
RA4368       25010       25011      0.53870E-02
VA4368       25009       25010 AC   0.00000E+00
LA4368       25008       25009      0.12767E-08
CA4369       25014           0      0.94876E-15
RA4369       25014           0      0.41938E+09
RA4370       25013       25014      0.53870E-02
VA4370       25012       25013 AC   0.00000E+00
LA4370       25011       25012      0.12767E-08
CA4371       25017           0      0.94876E-15
RA4371       25017           0      0.41938E+09
RA4372       25016       25017      0.53870E-02
VA4372       25015       25016 AC   0.00000E+00
LA4372       25014       25015      0.12767E-08
CA4373       25020           0      0.94876E-15
RA4373       25020           0      0.41938E+09
RA4374       25019       25020      0.53870E-02
VA4374       25018       25019 AC   0.00000E+00
LA4374       25017       25018      0.12767E-08
CA4375       25023           0      0.94876E-15
RA4375       25023           0      0.41938E+09
RA4376       25022       25023      0.53870E-02
VA4376       25021       25022 AC   0.00000E+00
LA4376       25020       25021      0.12767E-08
CA4377       25026           0      0.94876E-15
RA4377       25026           0      0.41938E+09
RA4378       25025       25026      0.53870E-02
VA4378       25024       25025 AC   0.00000E+00
LA4378       25023       25024      0.12767E-08
CA4379       25029           0      0.94876E-15
RA4379       25029           0      0.41938E+09
RA4380       25028       25029      0.53870E-02
VA4380       25027       25028 AC   0.00000E+00
LA4380       25026       25027      0.12767E-08
CA4381       25032           0      0.94876E-15
RA4381       25032           0      0.41938E+09
RA4382       25031       25032      0.53870E-02
VA4382       25030       25031 AC   0.00000E+00
LA4382       25029       25030      0.12767E-08
CA4383       25035           0      0.94876E-15
RA4383       25035           0      0.41938E+09
RA4384       25034       25035      0.53870E-02
VA4384       25033       25034 AC   0.00000E+00
LA4384       25032       25033      0.12767E-08
CA4385       25038           0      0.94876E-15
RA4385       25038           0      0.41938E+09
RA4386       25037       25038      0.53870E-02
VA4386       25036       25037 AC   0.00000E+00
LA4386       25035       25036      0.12767E-08
CA4387       25041           0      0.94876E-15
RA4387       25041           0      0.41938E+09
RA4388       25040       25041      0.53870E-02
VA4388       25039       25040 AC   0.00000E+00
LA4388       25038       25039      0.12767E-08
CA4389       25044           0      0.18149E-14
RA4389       25044           0      0.41938E+09
RA4390       25043       25044      0.53870E-02
VA4390       25042       25043 AC   0.00000E+00
LA4390       25041       25042      0.12767E-08
RA4391           0       25045      0.26935E-02
VA4391       25045       25046 AC   0.00000E+00
LA4391       25046       25047      0.63835E-09
CA4392       25047           0      0.94876E-15
RA4392       25047           0      0.41938E+09
CA4393       25050           0      0.94876E-15
RA4393       25050           0      0.41938E+09
RA4394       25049       25050      0.53870E-02
VA4394       25048       25049 AC   0.00000E+00
LA4394       25047       25048      0.12767E-08
CA4395       25053           0      0.94876E-15
RA4395       25053           0      0.41938E+09
RA4396       25052       25053      0.53870E-02
VA4396       25051       25052 AC   0.00000E+00
LA4396       25050       25051      0.12767E-08
CA4397       25056           0      0.94876E-15
RA4397       25056           0      0.41938E+09
RA4398       25055       25056      0.53870E-02
VA4398       25054       25055 AC   0.00000E+00
LA4398       25053       25054      0.12767E-08
CA4399       25059           0      0.94876E-15
RA4399       25059           0      0.41938E+09
RA4400       25058       25059      0.53870E-02
VA4400       25057       25058 AC   0.00000E+00
LA4400       25056       25057      0.12767E-08
CA4401       25062           0      0.94876E-15
RA4401       25062           0      0.41938E+09
RA4402       25061       25062      0.53870E-02
VA4402       25060       25061 AC   0.00000E+00
LA4402       25059       25060      0.12767E-08
CA4403       25065           0      0.94876E-15
RA4403       25065           0      0.41938E+09
RA4404       25064       25065      0.53870E-02
VA4404       25063       25064 AC   0.00000E+00
LA4404       25062       25063      0.12767E-08
CA4405       25068           0      0.94876E-15
RA4405       25068           0      0.41938E+09
RA4406       25067       25068      0.53870E-02
VA4406       25066       25067 AC   0.00000E+00
LA4406       25065       25066      0.12767E-08
CA4407       25071           0      0.94876E-15
RA4407       25071           0      0.41938E+09
RA4408       25070       25071      0.53870E-02
VA4408       25069       25070 AC   0.00000E+00
LA4408       25068       25069      0.12767E-08
CA4409       25074           0      0.94876E-15
RA4409       25074           0      0.41938E+09
RA4410       25073       25074      0.53870E-02
VA4410       25072       25073 AC   0.00000E+00
LA4410       25071       25072      0.12767E-08
CA4411       25077           0      0.94876E-15
RA4411       25077           0      0.41938E+09
RA4412       25076       25077      0.53870E-02
VA4412       25075       25076 AC   0.00000E+00
LA4412       25074       25075      0.12767E-08
CA4413       25080           0      0.94876E-15
RA4413       25080           0      0.41938E+09
RA4414       25079       25080      0.53870E-02
VA4414       25078       25079 AC   0.00000E+00
LA4414       25077       25078      0.12767E-08
CA4415       25083           0      0.94876E-15
RA4415       25083           0      0.41938E+09
RA4416       25082       25083      0.53870E-02
VA4416       25081       25082 AC   0.00000E+00
LA4416       25080       25081      0.12767E-08
CA4417       25086           0      0.94876E-15
RA4417       25086           0      0.41938E+09
RA4418       25085       25086      0.53870E-02
VA4418       25084       25085 AC   0.00000E+00
LA4418       25083       25084      0.12767E-08
CA4419       25089           0      0.94876E-15
RA4419       25089           0      0.41938E+09
RA4420       25088       25089      0.53870E-02
VA4420       25087       25088 AC   0.00000E+00
LA4420       25086       25087      0.12767E-08
CA4421       25092           0      0.94876E-15
RA4421       25092           0      0.41938E+09
RA4422       25091       25092      0.53870E-02
VA4422       25090       25091 AC   0.00000E+00
LA4422       25089       25090      0.12767E-08
CA4423       25095           0      0.94876E-15
RA4423       25095           0      0.41938E+09
RA4424       25094       25095      0.53870E-02
VA4424       25093       25094 AC   0.00000E+00
LA4424       25092       25093      0.12767E-08
CA4425       25098           0      0.94876E-15
RA4425       25098           0      0.41938E+09
RA4426       25097       25098      0.53870E-02
VA4426       25096       25097 AC   0.00000E+00
LA4426       25095       25096      0.12767E-08
CA4427       25101           0      0.94876E-15
RA4427       25101           0      0.41938E+09
RA4428       25100       25101      0.53870E-02
VA4428       25099       25100 AC   0.00000E+00
LA4428       25098       25099      0.12767E-08
CA4429       25104           0      0.94876E-15
RA4429       25104           0      0.41938E+09
RA4430       25103       25104      0.53870E-02
VA4430       25102       25103 AC   0.00000E+00
LA4430       25101       25102      0.12767E-08
CA4431       25107           0      0.94876E-15
RA4431       25107           0      0.41938E+09
RA4432       25106       25107      0.53870E-02
VA4432       25105       25106 AC   0.00000E+00
LA4432       25104       25105      0.12767E-08
CA4433       25110           0      0.94876E-15
RA4433       25110           0      0.41938E+09
RA4434       25109       25110      0.53870E-02
VA4434       25108       25109 AC   0.00000E+00
LA4434       25107       25108      0.12767E-08
CA4435       25113           0      0.94876E-15
RA4435       25113           0      0.41938E+09
RA4436       25112       25113      0.53870E-02
VA4436       25111       25112 AC   0.00000E+00
LA4436       25110       25111      0.12767E-08
CA4437       25116           0      0.94876E-15
RA4437       25116           0      0.41938E+09
RA4438       25115       25116      0.53870E-02
VA4438       25114       25115 AC   0.00000E+00
LA4438       25113       25114      0.12767E-08
CA4439       25119           0      0.94876E-15
RA4439       25119           0      0.41938E+09
RA4440       25118       25119      0.53870E-02
VA4440       25117       25118 AC   0.00000E+00
LA4440       25116       25117      0.12767E-08
CA4441       25122           0      0.94876E-15
RA4441       25122           0      0.41938E+09
RA4442       25121       25122      0.53870E-02
VA4442       25120       25121 AC   0.00000E+00
LA4442       25119       25120      0.12767E-08
CA4443       25125           0      0.94876E-15
RA4443       25125           0      0.41938E+09
RA4444       25124       25125      0.53870E-02
VA4444       25123       25124 AC   0.00000E+00
LA4444       25122       25123      0.12767E-08
CA4445       25128           0      0.94876E-15
RA4445       25128           0      0.41938E+09
RA4446       25127       25128      0.53870E-02
VA4446       25126       25127 AC   0.00000E+00
LA4446       25125       25126      0.12767E-08
CA4447       25131           0      0.94876E-15
RA4447       25131           0      0.41938E+09
RA4448       25130       25131      0.53870E-02
VA4448       25129       25130 AC   0.00000E+00
LA4448       25128       25129      0.12767E-08
CA4449       25134           0      0.94876E-15
RA4449       25134           0      0.41938E+09
RA4450       25133       25134      0.53870E-02
VA4450       25132       25133 AC   0.00000E+00
LA4450       25131       25132      0.12767E-08
CA4451       25137           0      0.94876E-15
RA4451       25137           0      0.41938E+09
RA4452       25136       25137      0.53870E-02
VA4452       25135       25136 AC   0.00000E+00
LA4452       25134       25135      0.12767E-08
CA4453       25140           0      0.94876E-15
RA4453       25140           0      0.41938E+09
RA4454       25139       25140      0.53870E-02
VA4454       25138       25139 AC   0.00000E+00
LA4454       25137       25138      0.12767E-08
CA4455       25143           0      0.94876E-15
RA4455       25143           0      0.41938E+09
RA4456       25142       25143      0.53870E-02
VA4456       25141       25142 AC   0.00000E+00
LA4456       25140       25141      0.12767E-08
CA4457       25146           0      0.94876E-15
RA4457       25146           0      0.41938E+09
RA4458       25145       25146      0.53870E-02
VA4458       25144       25145 AC   0.00000E+00
LA4458       25143       25144      0.12767E-08
CA4459       25149           0      0.94876E-15
RA4459       25149           0      0.41938E+09
RA4460       25148       25149      0.53870E-02
VA4460       25147       25148 AC   0.00000E+00
LA4460       25146       25147      0.12767E-08
CA4461       25152           0      0.94876E-15
RA4461       25152           0      0.41938E+09
RA4462       25151       25152      0.53870E-02
VA4462       25150       25151 AC   0.00000E+00
LA4462       25149       25150      0.12767E-08
CA4463       25155           0      0.94876E-15
RA4463       25155           0      0.41938E+09
RA4464       25154       25155      0.53870E-02
VA4464       25153       25154 AC   0.00000E+00
LA4464       25152       25153      0.12767E-08
CA4465       25158           0      0.94876E-15
RA4465       25158           0      0.41938E+09
RA4466       25157       25158      0.53870E-02
VA4466       25156       25157 AC   0.00000E+00
LA4466       25155       25156      0.12767E-08
CA4467       25161           0      0.94876E-15
RA4467       25161           0      0.41938E+09
RA4468       25160       25161      0.53870E-02
VA4468       25159       25160 AC   0.00000E+00
LA4468       25158       25159      0.12767E-08
CA4469       25164           0      0.94876E-15
RA4469       25164           0      0.41938E+09
RA4470       25163       25164      0.53870E-02
VA4470       25162       25163 AC   0.00000E+00
LA4470       25161       25162      0.12767E-08
CA4471       25167           0      0.94876E-15
RA4471       25167           0      0.41938E+09
RA4472       25166       25167      0.53870E-02
VA4472       25165       25166 AC   0.00000E+00
LA4472       25164       25165      0.12767E-08
CA4473       25170           0      0.94876E-15
RA4473       25170           0      0.41938E+09
RA4474       25169       25170      0.53870E-02
VA4474       25168       25169 AC   0.00000E+00
LA4474       25167       25168      0.12767E-08
CA4475       25173           0      0.94876E-15
RA4475       25173           0      0.41938E+09
RA4476       25172       25173      0.53870E-02
VA4476       25171       25172 AC   0.00000E+00
LA4476       25170       25171      0.12767E-08
CA4477       25176           0      0.94876E-15
RA4477       25176           0      0.41938E+09
RA4478       25175       25176      0.53870E-02
VA4478       25174       25175 AC   0.00000E+00
LA4478       25173       25174      0.12767E-08
CA4479       25179           0      0.94876E-15
RA4479       25179           0      0.41938E+09
RA4480       25178       25179      0.53870E-02
VA4480       25177       25178 AC   0.00000E+00
LA4480       25176       25177      0.12767E-08
CA4481       25182           0      0.18149E-14
RA4481       25182           0      0.41938E+09
RA4482       25181       25182      0.53870E-02
VA4482       25180       25181 AC   0.00000E+00
LA4482       25179       25180      0.12767E-08
RA4483           0       25183      0.26935E-02
VA4483       25183       25184 AC   0.00000E+00
LA4483       25184       25185      0.63835E-09
CA4484       25185           0      0.94876E-15
RA4484       25185           0      0.41938E+09
CA4485       25188           0      0.94876E-15
RA4485       25188           0      0.41938E+09
RA4486       25187       25188      0.53870E-02
VA4486       25186       25187 AC   0.00000E+00
LA4486       25185       25186      0.12767E-08
CA4487       25191           0      0.94876E-15
RA4487       25191           0      0.41938E+09
RA4488       25190       25191      0.53870E-02
VA4488       25189       25190 AC   0.00000E+00
LA4488       25188       25189      0.12767E-08
CA4489       25194           0      0.94876E-15
RA4489       25194           0      0.41938E+09
RA4490       25193       25194      0.53870E-02
VA4490       25192       25193 AC   0.00000E+00
LA4490       25191       25192      0.12767E-08
CA4491       25197           0      0.94876E-15
RA4491       25197           0      0.41938E+09
RA4492       25196       25197      0.53870E-02
VA4492       25195       25196 AC   0.00000E+00
LA4492       25194       25195      0.12767E-08
CA4493       25200           0      0.94876E-15
RA4493       25200           0      0.41938E+09
RA4494       25199       25200      0.53870E-02
VA4494       25198       25199 AC   0.00000E+00
LA4494       25197       25198      0.12767E-08
CA4495       25203           0      0.94876E-15
RA4495       25203           0      0.41938E+09
RA4496       25202       25203      0.53870E-02
VA4496       25201       25202 AC   0.00000E+00
LA4496       25200       25201      0.12767E-08
CA4497       25206           0      0.94876E-15
RA4497       25206           0      0.41938E+09
RA4498       25205       25206      0.53870E-02
VA4498       25204       25205 AC   0.00000E+00
LA4498       25203       25204      0.12767E-08
CA4499       25209           0      0.94876E-15
RA4499       25209           0      0.41938E+09
RA4500       25208       25209      0.53870E-02
VA4500       25207       25208 AC   0.00000E+00
LA4500       25206       25207      0.12767E-08
CA4501       25212           0      0.94876E-15
RA4501       25212           0      0.41938E+09
RA4502       25211       25212      0.53870E-02
VA4502       25210       25211 AC   0.00000E+00
LA4502       25209       25210      0.12767E-08
CA4503       25215           0      0.94876E-15
RA4503       25215           0      0.41938E+09
RA4504       25214       25215      0.53870E-02
VA4504       25213       25214 AC   0.00000E+00
LA4504       25212       25213      0.12767E-08
CA4505       25218           0      0.94876E-15
RA4505       25218           0      0.41938E+09
RA4506       25217       25218      0.53870E-02
VA4506       25216       25217 AC   0.00000E+00
LA4506       25215       25216      0.12767E-08
CA4507       25221           0      0.94876E-15
RA4507       25221           0      0.41938E+09
RA4508       25220       25221      0.53870E-02
VA4508       25219       25220 AC   0.00000E+00
LA4508       25218       25219      0.12767E-08
CA4509       25224           0      0.94876E-15
RA4509       25224           0      0.41938E+09
RA4510       25223       25224      0.53870E-02
VA4510       25222       25223 AC   0.00000E+00
LA4510       25221       25222      0.12767E-08
CA4511       25227           0      0.94876E-15
RA4511       25227           0      0.41938E+09
RA4512       25226       25227      0.53870E-02
VA4512       25225       25226 AC   0.00000E+00
LA4512       25224       25225      0.12767E-08
CA4513       25230           0      0.94876E-15
RA4513       25230           0      0.41938E+09
RA4514       25229       25230      0.53870E-02
VA4514       25228       25229 AC   0.00000E+00
LA4514       25227       25228      0.12767E-08
CA4515       25233           0      0.94876E-15
RA4515       25233           0      0.41938E+09
RA4516       25232       25233      0.53870E-02
VA4516       25231       25232 AC   0.00000E+00
LA4516       25230       25231      0.12767E-08
CA4517       25236           0      0.94876E-15
RA4517       25236           0      0.41938E+09
RA4518       25235       25236      0.53870E-02
VA4518       25234       25235 AC   0.00000E+00
LA4518       25233       25234      0.12767E-08
CA4519       25239           0      0.94876E-15
RA4519       25239           0      0.41938E+09
RA4520       25238       25239      0.53870E-02
VA4520       25237       25238 AC   0.00000E+00
LA4520       25236       25237      0.12767E-08
CA4521       25242           0      0.94876E-15
RA4521       25242           0      0.41938E+09
RA4522       25241       25242      0.53870E-02
VA4522       25240       25241 AC   0.00000E+00
LA4522       25239       25240      0.12767E-08
CA4523       25245           0      0.94876E-15
RA4523       25245           0      0.41938E+09
RA4524       25244       25245      0.53870E-02
VA4524       25243       25244 AC   0.00000E+00
LA4524       25242       25243      0.12767E-08
CA4525       25248           0      0.94876E-15
RA4525       25248           0      0.41938E+09
RA4526       25247       25248      0.53870E-02
VA4526       25246       25247 AC   0.00000E+00
LA4526       25245       25246      0.12767E-08
CA4527       25251           0      0.94876E-15
RA4527       25251           0      0.41938E+09
RA4528       25250       25251      0.53870E-02
VA4528       25249       25250 AC   0.00000E+00
LA4528       25248       25249      0.12767E-08
CA4529       25254           0      0.94876E-15
RA4529       25254           0      0.41938E+09
RA4530       25253       25254      0.53870E-02
VA4530       25252       25253 AC   0.00000E+00
LA4530       25251       25252      0.12767E-08
CA4531       25257           0      0.94876E-15
RA4531       25257           0      0.41938E+09
RA4532       25256       25257      0.53870E-02
VA4532       25255       25256 AC   0.00000E+00
LA4532       25254       25255      0.12767E-08
CA4533       25260           0      0.94876E-15
RA4533       25260           0      0.41938E+09
RA4534       25259       25260      0.53870E-02
VA4534       25258       25259 AC   0.00000E+00
LA4534       25257       25258      0.12767E-08
CA4535       25263           0      0.94876E-15
RA4535       25263           0      0.41938E+09
RA4536       25262       25263      0.53870E-02
VA4536       25261       25262 AC   0.00000E+00
LA4536       25260       25261      0.12767E-08
CA4537       25266           0      0.94876E-15
RA4537       25266           0      0.41938E+09
RA4538       25265       25266      0.53870E-02
VA4538       25264       25265 AC   0.00000E+00
LA4538       25263       25264      0.12767E-08
CA4539       25269           0      0.94876E-15
RA4539       25269           0      0.41938E+09
RA4540       25268       25269      0.53870E-02
VA4540       25267       25268 AC   0.00000E+00
LA4540       25266       25267      0.12767E-08
CA4541       25272           0      0.94876E-15
RA4541       25272           0      0.41938E+09
RA4542       25271       25272      0.53870E-02
VA4542       25270       25271 AC   0.00000E+00
LA4542       25269       25270      0.12767E-08
CA4543       25275           0      0.94876E-15
RA4543       25275           0      0.41938E+09
RA4544       25274       25275      0.53870E-02
VA4544       25273       25274 AC   0.00000E+00
LA4544       25272       25273      0.12767E-08
CA4545       25278           0      0.94876E-15
RA4545       25278           0      0.41938E+09
RA4546       25277       25278      0.53870E-02
VA4546       25276       25277 AC   0.00000E+00
LA4546       25275       25276      0.12767E-08
CA4547       25281           0      0.94876E-15
RA4547       25281           0      0.41938E+09
RA4548       25280       25281      0.53870E-02
VA4548       25279       25280 AC   0.00000E+00
LA4548       25278       25279      0.12767E-08
CA4549       25284           0      0.94876E-15
RA4549       25284           0      0.41938E+09
RA4550       25283       25284      0.53870E-02
VA4550       25282       25283 AC   0.00000E+00
LA4550       25281       25282      0.12767E-08
CA4551       25287           0      0.94876E-15
RA4551       25287           0      0.41938E+09
RA4552       25286       25287      0.53870E-02
VA4552       25285       25286 AC   0.00000E+00
LA4552       25284       25285      0.12767E-08
CA4553       25290           0      0.94876E-15
RA4553       25290           0      0.41938E+09
RA4554       25289       25290      0.53870E-02
VA4554       25288       25289 AC   0.00000E+00
LA4554       25287       25288      0.12767E-08
CA4555       25293           0      0.94876E-15
RA4555       25293           0      0.41938E+09
RA4556       25292       25293      0.53870E-02
VA4556       25291       25292 AC   0.00000E+00
LA4556       25290       25291      0.12767E-08
CA4557       25296           0      0.94876E-15
RA4557       25296           0      0.41938E+09
RA4558       25295       25296      0.53870E-02
VA4558       25294       25295 AC   0.00000E+00
LA4558       25293       25294      0.12767E-08
CA4559       25299           0      0.94876E-15
RA4559       25299           0      0.41938E+09
RA4560       25298       25299      0.53870E-02
VA4560       25297       25298 AC   0.00000E+00
LA4560       25296       25297      0.12767E-08
CA4561       25302           0      0.94876E-15
RA4561       25302           0      0.41938E+09
RA4562       25301       25302      0.53870E-02
VA4562       25300       25301 AC   0.00000E+00
LA4562       25299       25300      0.12767E-08
CA4563       25305           0      0.94876E-15
RA4563       25305           0      0.41938E+09
RA4564       25304       25305      0.53870E-02
VA4564       25303       25304 AC   0.00000E+00
LA4564       25302       25303      0.12767E-08
CA4565       25308           0      0.94876E-15
RA4565       25308           0      0.41938E+09
RA4566       25307       25308      0.53870E-02
VA4566       25306       25307 AC   0.00000E+00
LA4566       25305       25306      0.12767E-08
CA4567       25311           0      0.94876E-15
RA4567       25311           0      0.41938E+09
RA4568       25310       25311      0.53870E-02
VA4568       25309       25310 AC   0.00000E+00
LA4568       25308       25309      0.12767E-08
CA4569       25314           0      0.94876E-15
RA4569       25314           0      0.41938E+09
RA4570       25313       25314      0.53870E-02
VA4570       25312       25313 AC   0.00000E+00
LA4570       25311       25312      0.12767E-08
CA4571       25317           0      0.94876E-15
RA4571       25317           0      0.41938E+09
RA4572       25316       25317      0.53870E-02
VA4572       25315       25316 AC   0.00000E+00
LA4572       25314       25315      0.12767E-08
CA4573       25320           0      0.18149E-14
RA4573       25320           0      0.41938E+09
RA4574       25319       25320      0.53870E-02
VA4574       25318       25319 AC   0.00000E+00
LA4574       25317       25318      0.12767E-08
RA4575           0       25321      0.26935E-02
VA4575       25321       25322 AC   0.00000E+00
LA4575       25322       25323      0.63835E-09
CA4576       25323           0      0.94876E-15
RA4576       25323           0      0.41938E+09
CA4577       25326           0      0.94876E-15
RA4577       25326           0      0.41938E+09
RA4578       25325       25326      0.53870E-02
VA4578       25324       25325 AC   0.00000E+00
LA4578       25323       25324      0.12767E-08
CA4579       25329           0      0.94876E-15
RA4579       25329           0      0.41938E+09
RA4580       25328       25329      0.53870E-02
VA4580       25327       25328 AC   0.00000E+00
LA4580       25326       25327      0.12767E-08
CA4581       25332           0      0.94876E-15
RA4581       25332           0      0.41938E+09
RA4582       25331       25332      0.53870E-02
VA4582       25330       25331 AC   0.00000E+00
LA4582       25329       25330      0.12767E-08
CA4583       25335           0      0.94876E-15
RA4583       25335           0      0.41938E+09
RA4584       25334       25335      0.53870E-02
VA4584       25333       25334 AC   0.00000E+00
LA4584       25332       25333      0.12767E-08
CA4585       25338           0      0.94876E-15
RA4585       25338           0      0.41938E+09
RA4586       25337       25338      0.53870E-02
VA4586       25336       25337 AC   0.00000E+00
LA4586       25335       25336      0.12767E-08
CA4587       25341           0      0.94876E-15
RA4587       25341           0      0.41938E+09
RA4588       25340       25341      0.53870E-02
VA4588       25339       25340 AC   0.00000E+00
LA4588       25338       25339      0.12767E-08
CA4589       25344           0      0.94876E-15
RA4589       25344           0      0.41938E+09
RA4590       25343       25344      0.53870E-02
VA4590       25342       25343 AC   0.00000E+00
LA4590       25341       25342      0.12767E-08
CA4591       25347           0      0.94876E-15
RA4591       25347           0      0.41938E+09
RA4592       25346       25347      0.53870E-02
VA4592       25345       25346 AC   0.00000E+00
LA4592       25344       25345      0.12767E-08
CA4593       25350           0      0.94876E-15
RA4593       25350           0      0.41938E+09
RA4594       25349       25350      0.53870E-02
VA4594       25348       25349 AC   0.00000E+00
LA4594       25347       25348      0.12767E-08
CA4595       25353           0      0.94876E-15
RA4595       25353           0      0.41938E+09
RA4596       25352       25353      0.53870E-02
VA4596       25351       25352 AC   0.00000E+00
LA4596       25350       25351      0.12767E-08
CA4597       25356           0      0.94876E-15
RA4597       25356           0      0.41938E+09
RA4598       25355       25356      0.53870E-02
VA4598       25354       25355 AC   0.00000E+00
LA4598       25353       25354      0.12767E-08
CA4599       25359           0      0.94876E-15
RA4599       25359           0      0.41938E+09
RA4600       25358       25359      0.53870E-02
VA4600       25357       25358 AC   0.00000E+00
LA4600       25356       25357      0.12767E-08
CA4601       25362           0      0.94876E-15
RA4601       25362           0      0.41938E+09
RA4602       25361       25362      0.53870E-02
VA4602       25360       25361 AC   0.00000E+00
LA4602       25359       25360      0.12767E-08
CA4603       25365           0      0.94876E-15
RA4603       25365           0      0.41938E+09
RA4604       25364       25365      0.53870E-02
VA4604       25363       25364 AC   0.00000E+00
LA4604       25362       25363      0.12767E-08
CA4605       25368           0      0.94876E-15
RA4605       25368           0      0.41938E+09
RA4606       25367       25368      0.53870E-02
VA4606       25366       25367 AC   0.00000E+00
LA4606       25365       25366      0.12767E-08
CA4607       25371           0      0.94876E-15
RA4607       25371           0      0.41938E+09
RA4608       25370       25371      0.53870E-02
VA4608       25369       25370 AC   0.00000E+00
LA4608       25368       25369      0.12767E-08
CA4609       25374           0      0.94876E-15
RA4609       25374           0      0.41938E+09
RA4610       25373       25374      0.53870E-02
VA4610       25372       25373 AC   0.00000E+00
LA4610       25371       25372      0.12767E-08
CA4611       25377           0      0.94876E-15
RA4611       25377           0      0.41938E+09
RA4612       25376       25377      0.53870E-02
VA4612       25375       25376 AC   0.00000E+00
LA4612       25374       25375      0.12767E-08
CA4613       25380           0      0.94876E-15
RA4613       25380           0      0.41938E+09
RA4614       25379       25380      0.53870E-02
VA4614       25378       25379 AC   0.00000E+00
LA4614       25377       25378      0.12767E-08
CA4615       25383           0      0.94876E-15
RA4615       25383           0      0.41938E+09
RA4616       25382       25383      0.53870E-02
VA4616       25381       25382 AC   0.00000E+00
LA4616       25380       25381      0.12767E-08
CA4617       25386           0      0.94876E-15
RA4617       25386           0      0.41938E+09
RA4618       25385       25386      0.53870E-02
VA4618       25384       25385 AC   0.00000E+00
LA4618       25383       25384      0.12767E-08
CA4619       25389           0      0.94876E-15
RA4619       25389           0      0.41938E+09
RA4620       25388       25389      0.53870E-02
VA4620       25387       25388 AC   0.00000E+00
LA4620       25386       25387      0.12767E-08
CA4621       25392           0      0.94876E-15
RA4621       25392           0      0.41938E+09
RA4622       25391       25392      0.53870E-02
VA4622       25390       25391 AC   0.00000E+00
LA4622       25389       25390      0.12767E-08
CA4623       25395           0      0.94876E-15
RA4623       25395           0      0.41938E+09
RA4624       25394       25395      0.53870E-02
VA4624       25393       25394 AC   0.00000E+00
LA4624       25392       25393      0.12767E-08
CA4625       25398           0      0.94876E-15
RA4625       25398           0      0.41938E+09
RA4626       25397       25398      0.53870E-02
VA4626       25396       25397 AC   0.00000E+00
LA4626       25395       25396      0.12767E-08
CA4627       25401           0      0.94876E-15
RA4627       25401           0      0.41938E+09
RA4628       25400       25401      0.53870E-02
VA4628       25399       25400 AC   0.00000E+00
LA4628       25398       25399      0.12767E-08
CA4629       25404           0      0.94876E-15
RA4629       25404           0      0.41938E+09
RA4630       25403       25404      0.53870E-02
VA4630       25402       25403 AC   0.00000E+00
LA4630       25401       25402      0.12767E-08
CA4631       25407           0      0.94876E-15
RA4631       25407           0      0.41938E+09
RA4632       25406       25407      0.53870E-02
VA4632       25405       25406 AC   0.00000E+00
LA4632       25404       25405      0.12767E-08
CA4633       25410           0      0.94876E-15
RA4633       25410           0      0.41938E+09
RA4634       25409       25410      0.53870E-02
VA4634       25408       25409 AC   0.00000E+00
LA4634       25407       25408      0.12767E-08
CA4635       25413           0      0.94876E-15
RA4635       25413           0      0.41938E+09
RA4636       25412       25413      0.53870E-02
VA4636       25411       25412 AC   0.00000E+00
LA4636       25410       25411      0.12767E-08
CA4637       25416           0      0.94876E-15
RA4637       25416           0      0.41938E+09
RA4638       25415       25416      0.53870E-02
VA4638       25414       25415 AC   0.00000E+00
LA4638       25413       25414      0.12767E-08
CA4639       25419           0      0.94876E-15
RA4639       25419           0      0.41938E+09
RA4640       25418       25419      0.53870E-02
VA4640       25417       25418 AC   0.00000E+00
LA4640       25416       25417      0.12767E-08
CA4641       25422           0      0.94876E-15
RA4641       25422           0      0.41938E+09
RA4642       25421       25422      0.53870E-02
VA4642       25420       25421 AC   0.00000E+00
LA4642       25419       25420      0.12767E-08
CA4643       25425           0      0.94876E-15
RA4643       25425           0      0.41938E+09
RA4644       25424       25425      0.53870E-02
VA4644       25423       25424 AC   0.00000E+00
LA4644       25422       25423      0.12767E-08
CA4645       25428           0      0.94876E-15
RA4645       25428           0      0.41938E+09
RA4646       25427       25428      0.53870E-02
VA4646       25426       25427 AC   0.00000E+00
LA4646       25425       25426      0.12767E-08
CA4647       25431           0      0.94876E-15
RA4647       25431           0      0.41938E+09
RA4648       25430       25431      0.53870E-02
VA4648       25429       25430 AC   0.00000E+00
LA4648       25428       25429      0.12767E-08
CA4649       25434           0      0.94876E-15
RA4649       25434           0      0.41938E+09
RA4650       25433       25434      0.53870E-02
VA4650       25432       25433 AC   0.00000E+00
LA4650       25431       25432      0.12767E-08
CA4651       25437           0      0.94876E-15
RA4651       25437           0      0.41938E+09
RA4652       25436       25437      0.53870E-02
VA4652       25435       25436 AC   0.00000E+00
LA4652       25434       25435      0.12767E-08
CA4653       25440           0      0.94876E-15
RA4653       25440           0      0.41938E+09
RA4654       25439       25440      0.53870E-02
VA4654       25438       25439 AC   0.00000E+00
LA4654       25437       25438      0.12767E-08
CA4655       25443           0      0.94876E-15
RA4655       25443           0      0.41938E+09
RA4656       25442       25443      0.53870E-02
VA4656       25441       25442 AC   0.00000E+00
LA4656       25440       25441      0.12767E-08
CA4657       25446           0      0.94876E-15
RA4657       25446           0      0.41938E+09
RA4658       25445       25446      0.53870E-02
VA4658       25444       25445 AC   0.00000E+00
LA4658       25443       25444      0.12767E-08
CA4659       25449           0      0.94876E-15
RA4659       25449           0      0.41938E+09
RA4660       25448       25449      0.53870E-02
VA4660       25447       25448 AC   0.00000E+00
LA4660       25446       25447      0.12767E-08
CA4661       25452           0      0.94876E-15
RA4661       25452           0      0.41938E+09
RA4662       25451       25452      0.53870E-02
VA4662       25450       25451 AC   0.00000E+00
LA4662       25449       25450      0.12767E-08
CA4663       25455           0      0.94876E-15
RA4663       25455           0      0.41938E+09
RA4664       25454       25455      0.53870E-02
VA4664       25453       25454 AC   0.00000E+00
LA4664       25452       25453      0.12767E-08
CA4665       25458           0      0.18149E-14
RA4665       25458           0      0.41938E+09
RA4666       25457       25458      0.53870E-02
VA4666       25456       25457 AC   0.00000E+00
LA4666       25455       25456      0.12767E-08
RA4667           0       25459      0.26935E-02
VA4667       25459       25460 AC   0.00000E+00
LA4667       25460       25461      0.63835E-09
CA4668       25461           0      0.94876E-15
RA4668       25461           0      0.41938E+09
CA4669       25464           0      0.94876E-15
RA4669       25464           0      0.41938E+09
RA4670       25463       25464      0.53870E-02
VA4670       25462       25463 AC   0.00000E+00
LA4670       25461       25462      0.12767E-08
CA4671       25467           0      0.94876E-15
RA4671       25467           0      0.41938E+09
RA4672       25466       25467      0.53870E-02
VA4672       25465       25466 AC   0.00000E+00
LA4672       25464       25465      0.12767E-08
CA4673       25470           0      0.94876E-15
RA4673       25470           0      0.41938E+09
RA4674       25469       25470      0.53870E-02
VA4674       25468       25469 AC   0.00000E+00
LA4674       25467       25468      0.12767E-08
CA4675       25473           0      0.94876E-15
RA4675       25473           0      0.41938E+09
RA4676       25472       25473      0.53870E-02
VA4676       25471       25472 AC   0.00000E+00
LA4676       25470       25471      0.12767E-08
CA4677       25476           0      0.94876E-15
RA4677       25476           0      0.41938E+09
RA4678       25475       25476      0.53870E-02
VA4678       25474       25475 AC   0.00000E+00
LA4678       25473       25474      0.12767E-08
CA4679       25479           0      0.94876E-15
RA4679       25479           0      0.41938E+09
RA4680       25478       25479      0.53870E-02
VA4680       25477       25478 AC   0.00000E+00
LA4680       25476       25477      0.12767E-08
CA4681       25482           0      0.94876E-15
RA4681       25482           0      0.41938E+09
RA4682       25481       25482      0.53870E-02
VA4682       25480       25481 AC   0.00000E+00
LA4682       25479       25480      0.12767E-08
CA4683       25485           0      0.94876E-15
RA4683       25485           0      0.41938E+09
RA4684       25484       25485      0.53870E-02
VA4684       25483       25484 AC   0.00000E+00
LA4684       25482       25483      0.12767E-08
CA4685       25488           0      0.94876E-15
RA4685       25488           0      0.41938E+09
RA4686       25487       25488      0.53870E-02
VA4686       25486       25487 AC   0.00000E+00
LA4686       25485       25486      0.12767E-08
CA4687       25491           0      0.94876E-15
RA4687       25491           0      0.41938E+09
RA4688       25490       25491      0.53870E-02
VA4688       25489       25490 AC   0.00000E+00
LA4688       25488       25489      0.12767E-08
CA4689       25494           0      0.94876E-15
RA4689       25494           0      0.41938E+09
RA4690       25493       25494      0.53870E-02
VA4690       25492       25493 AC   0.00000E+00
LA4690       25491       25492      0.12767E-08
CA4691       25497           0      0.94876E-15
RA4691       25497           0      0.41938E+09
RA4692       25496       25497      0.53870E-02
VA4692       25495       25496 AC   0.00000E+00
LA4692       25494       25495      0.12767E-08
CA4693       25500           0      0.94876E-15
RA4693       25500           0      0.41938E+09
RA4694       25499       25500      0.53870E-02
VA4694       25498       25499 AC   0.00000E+00
LA4694       25497       25498      0.12767E-08
CA4695       25503           0      0.94876E-15
RA4695       25503           0      0.41938E+09
RA4696       25502       25503      0.53870E-02
VA4696       25501       25502 AC   0.00000E+00
LA4696       25500       25501      0.12767E-08
CA4697       25506           0      0.94876E-15
RA4697       25506           0      0.41938E+09
RA4698       25505       25506      0.53870E-02
VA4698       25504       25505 AC   0.00000E+00
LA4698       25503       25504      0.12767E-08
CA4699       25509           0      0.94876E-15
RA4699       25509           0      0.41938E+09
RA4700       25508       25509      0.53870E-02
VA4700       25507       25508 AC   0.00000E+00
LA4700       25506       25507      0.12767E-08
CA4701       25512           0      0.94876E-15
RA4701       25512           0      0.41938E+09
RA4702       25511       25512      0.53870E-02
VA4702       25510       25511 AC   0.00000E+00
LA4702       25509       25510      0.12767E-08
CA4703       25515           0      0.94876E-15
RA4703       25515           0      0.41938E+09
RA4704       25514       25515      0.53870E-02
VA4704       25513       25514 AC   0.00000E+00
LA4704       25512       25513      0.12767E-08
CA4705       25518           0      0.94876E-15
RA4705       25518           0      0.41938E+09
RA4706       25517       25518      0.53870E-02
VA4706       25516       25517 AC   0.00000E+00
LA4706       25515       25516      0.12767E-08
CA4707       25521           0      0.94876E-15
RA4707       25521           0      0.41938E+09
RA4708       25520       25521      0.53870E-02
VA4708       25519       25520 AC   0.00000E+00
LA4708       25518       25519      0.12767E-08
CA4709       25524           0      0.94876E-15
RA4709       25524           0      0.41938E+09
RA4710       25523       25524      0.53870E-02
VA4710       25522       25523 AC   0.00000E+00
LA4710       25521       25522      0.12767E-08
CA4711       25527           0      0.94876E-15
RA4711       25527           0      0.41938E+09
RA4712       25526       25527      0.53870E-02
VA4712       25525       25526 AC   0.00000E+00
LA4712       25524       25525      0.12767E-08
CA4713       25530           0      0.94876E-15
RA4713       25530           0      0.41938E+09
RA4714       25529       25530      0.53870E-02
VA4714       25528       25529 AC   0.00000E+00
LA4714       25527       25528      0.12767E-08
CA4715       25533           0      0.94876E-15
RA4715       25533           0      0.41938E+09
RA4716       25532       25533      0.53870E-02
VA4716       25531       25532 AC   0.00000E+00
LA4716       25530       25531      0.12767E-08
CA4717       25536           0      0.94876E-15
RA4717       25536           0      0.41938E+09
RA4718       25535       25536      0.53870E-02
VA4718       25534       25535 AC   0.00000E+00
LA4718       25533       25534      0.12767E-08
CA4719       25539           0      0.94876E-15
RA4719       25539           0      0.41938E+09
RA4720       25538       25539      0.53870E-02
VA4720       25537       25538 AC   0.00000E+00
LA4720       25536       25537      0.12767E-08
CA4721       25542           0      0.94876E-15
RA4721       25542           0      0.41938E+09
RA4722       25541       25542      0.53870E-02
VA4722       25540       25541 AC   0.00000E+00
LA4722       25539       25540      0.12767E-08
CA4723       25545           0      0.94876E-15
RA4723       25545           0      0.41938E+09
RA4724       25544       25545      0.53870E-02
VA4724       25543       25544 AC   0.00000E+00
LA4724       25542       25543      0.12767E-08
CA4725       25548           0      0.94876E-15
RA4725       25548           0      0.41938E+09
RA4726       25547       25548      0.53870E-02
VA4726       25546       25547 AC   0.00000E+00
LA4726       25545       25546      0.12767E-08
CA4727       25551           0      0.94876E-15
RA4727       25551           0      0.41938E+09
RA4728       25550       25551      0.53870E-02
VA4728       25549       25550 AC   0.00000E+00
LA4728       25548       25549      0.12767E-08
CA4729       25554           0      0.94876E-15
RA4729       25554           0      0.41938E+09
RA4730       25553       25554      0.53870E-02
VA4730       25552       25553 AC   0.00000E+00
LA4730       25551       25552      0.12767E-08
CA4731       25557           0      0.94876E-15
RA4731       25557           0      0.41938E+09
RA4732       25556       25557      0.53870E-02
VA4732       25555       25556 AC   0.00000E+00
LA4732       25554       25555      0.12767E-08
CA4733       25560           0      0.94876E-15
RA4733       25560           0      0.41938E+09
RA4734       25559       25560      0.53870E-02
VA4734       25558       25559 AC   0.00000E+00
LA4734       25557       25558      0.12767E-08
CA4735       25563           0      0.94876E-15
RA4735       25563           0      0.41938E+09
RA4736       25562       25563      0.53870E-02
VA4736       25561       25562 AC   0.00000E+00
LA4736       25560       25561      0.12767E-08
CA4737       25566           0      0.94876E-15
RA4737       25566           0      0.41938E+09
RA4738       25565       25566      0.53870E-02
VA4738       25564       25565 AC   0.00000E+00
LA4738       25563       25564      0.12767E-08
CA4739       25569           0      0.94876E-15
RA4739       25569           0      0.41938E+09
RA4740       25568       25569      0.53870E-02
VA4740       25567       25568 AC   0.00000E+00
LA4740       25566       25567      0.12767E-08
CA4741       25572           0      0.94876E-15
RA4741       25572           0      0.41938E+09
RA4742       25571       25572      0.53870E-02
VA4742       25570       25571 AC   0.00000E+00
LA4742       25569       25570      0.12767E-08
CA4743       25575           0      0.94876E-15
RA4743       25575           0      0.41938E+09
RA4744       25574       25575      0.53870E-02
VA4744       25573       25574 AC   0.00000E+00
LA4744       25572       25573      0.12767E-08
CA4745       25578           0      0.94876E-15
RA4745       25578           0      0.41938E+09
RA4746       25577       25578      0.53870E-02
VA4746       25576       25577 AC   0.00000E+00
LA4746       25575       25576      0.12767E-08
CA4747       25581           0      0.94876E-15
RA4747       25581           0      0.41938E+09
RA4748       25580       25581      0.53870E-02
VA4748       25579       25580 AC   0.00000E+00
LA4748       25578       25579      0.12767E-08
CA4749       25584           0      0.94876E-15
RA4749       25584           0      0.41938E+09
RA4750       25583       25584      0.53870E-02
VA4750       25582       25583 AC   0.00000E+00
LA4750       25581       25582      0.12767E-08
CA4751       25587           0      0.94876E-15
RA4751       25587           0      0.41938E+09
RA4752       25586       25587      0.53870E-02
VA4752       25585       25586 AC   0.00000E+00
LA4752       25584       25585      0.12767E-08
CA4753       25590           0      0.94876E-15
RA4753       25590           0      0.41938E+09
RA4754       25589       25590      0.53870E-02
VA4754       25588       25589 AC   0.00000E+00
LA4754       25587       25588      0.12767E-08
CA4755       25593           0      0.94876E-15
RA4755       25593           0      0.41938E+09
RA4756       25592       25593      0.53870E-02
VA4756       25591       25592 AC   0.00000E+00
LA4756       25590       25591      0.12767E-08
CA4757       25596           0      0.18149E-14
RA4757       25596           0      0.41938E+09
RA4758       25595       25596      0.53870E-02
VA4758       25594       25595 AC   0.00000E+00
LA4758       25593       25594      0.12767E-08
RA4759           0       25597      0.26935E-02
VA4759       25597       25598 AC   0.00000E+00
LA4759       25598       25599      0.10357E-09
CA4760       25599           0      0.16718E-14
RA4760       25599           0      0.41938E+09
CA4761       25602           0      0.16718E-14
RA4761       25602           0      0.41938E+09
RA4762       25601       25602      0.53870E-02
VA4762       25600       25601 AC   0.00000E+00
LA4762       25599       25600      0.20715E-09
CA4763       25605           0      0.16718E-14
RA4763       25605           0      0.41938E+09
RA4764       25604       25605      0.53870E-02
VA4764       25603       25604 AC   0.00000E+00
LA4764       25602       25603      0.20715E-09
CA4765       25608           0      0.16718E-14
RA4765       25608           0      0.41938E+09
RA4766       25607       25608      0.53870E-02
VA4766       25606       25607 AC   0.00000E+00
LA4766       25605       25606      0.20715E-09
CA4767       25611           0      0.16718E-14
RA4767       25611           0      0.41938E+09
RA4768       25610       25611      0.53870E-02
VA4768       25609       25610 AC   0.00000E+00
LA4768       25608       25609      0.20715E-09
CA4769       25614           0      0.16718E-14
RA4769       25614           0      0.41938E+09
RA4770       25613       25614      0.53870E-02
VA4770       25612       25613 AC   0.00000E+00
LA4770       25611       25612      0.20715E-09
CA4771       25617           0      0.16718E-14
RA4771       25617           0      0.41938E+09
RA4772       25616       25617      0.53870E-02
VA4772       25615       25616 AC   0.00000E+00
LA4772       25614       25615      0.20715E-09
CA4773       25620           0      0.16718E-14
RA4773       25620           0      0.41938E+09
RA4774       25619       25620      0.53870E-02
VA4774       25618       25619 AC   0.00000E+00
LA4774       25617       25618      0.20715E-09
CA4775       25623           0      0.16718E-14
RA4775       25623           0      0.41938E+09
RA4776       25622       25623      0.53870E-02
VA4776       25621       25622 AC   0.00000E+00
LA4776       25620       25621      0.20715E-09
CA4777       25626           0      0.18886E-14
RA4777       25626           0      0.41938E+09
RA4778       25625       25626      0.53870E-02
VA4778       25624       25625 AC   0.00000E+00
LA4778       25623       25624      0.18601E-09
CA4779       25629           0      0.18886E-14
RA4779       25629           0      0.41938E+09
RA4780       25628       25629      0.53870E-02
VA4780       25627       25628 AC   0.00000E+00
LA4780       25626       25627      0.16488E-09
CA4781       25632           0      0.18886E-14
RA4781       25632           0      0.41938E+09
RA4782       25631       25632      0.53870E-02
VA4782       25630       25631 AC   0.00000E+00
LA4782       25629       25630      0.16488E-09
CA4783       25635           0      0.18886E-14
RA4783       25635           0      0.41938E+09
RA4784       25634       25635      0.53870E-02
VA4784       25633       25634 AC   0.00000E+00
LA4784       25632       25633      0.16488E-09
CA4785       25638           0      0.18886E-14
RA4785       25638           0      0.41938E+09
RA4786       25637       25638      0.53870E-02
VA4786       25636       25637 AC   0.00000E+00
LA4786       25635       25636      0.16488E-09
CA4787       25641           0      0.18886E-14
RA4787       25641           0      0.41938E+09
RA4788       25640       25641      0.53870E-02
VA4788       25639       25640 AC   0.00000E+00
LA4788       25638       25639      0.16488E-09
CA4789       25644           0      0.18886E-14
RA4789       25644           0      0.41938E+09
RA4790       25643       25644      0.53870E-02
VA4790       25642       25643 AC   0.00000E+00
LA4790       25641       25642      0.16488E-09
CA4791       25647           0      0.18886E-14
RA4791       25647           0      0.41938E+09
RA4792       25646       25647      0.53870E-02
VA4792       25645       25646 AC   0.00000E+00
LA4792       25644       25645      0.16488E-09
CA4793       25650           0      0.18886E-14
RA4793       25650           0      0.41938E+09
RA4794       25649       25650      0.53870E-02
VA4794       25648       25649 AC   0.00000E+00
LA4794       25647       25648      0.16488E-09
CA4795       25653           0      0.18886E-14
RA4795       25653           0      0.41938E+09
RA4796       25652       25653      0.53870E-02
VA4796       25651       25652 AC   0.00000E+00
LA4796       25650       25651      0.16488E-09
CA4797       25656           0      0.18886E-14
RA4797       25656           0      0.41938E+09
RA4798       25655       25656      0.53870E-02
VA4798       25654       25655 AC   0.00000E+00
LA4798       25653       25654      0.16488E-09
CA4799       25659           0      0.15706E-14
RA4799       25659           0      0.41938E+09
RA4800       25658       25659      0.53870E-02
VA4800       25657       25658 AC   0.00000E+00
LA4800       25656       25657      0.19988E-09
CA4801       25662           0      0.15706E-14
RA4801       25662           0      0.41938E+09
RA4802       25661       25662      0.53870E-02
VA4802       25660       25661 AC   0.00000E+00
LA4802       25659       25660      0.23489E-09
CA4803       25665           0      0.15706E-14
RA4803       25665           0      0.41938E+09
RA4804       25664       25665      0.53870E-02
VA4804       25663       25664 AC   0.00000E+00
LA4804       25662       25663      0.23489E-09
CA4805       25668           0      0.15706E-14
RA4805       25668           0      0.41938E+09
RA4806       25667       25668      0.53870E-02
VA4806       25666       25667 AC   0.00000E+00
LA4806       25665       25666      0.23489E-09
CA4807       25671           0      0.15706E-14
RA4807       25671           0      0.41938E+09
RA4808       25670       25671      0.53870E-02
VA4808       25669       25670 AC   0.00000E+00
LA4808       25668       25669      0.23489E-09
CA4809       25674           0      0.15706E-14
RA4809       25674           0      0.41938E+09
RA4810       25673       25674      0.53870E-02
VA4810       25672       25673 AC   0.00000E+00
LA4810       25671       25672      0.23489E-09
CA4811       25677           0      0.15706E-14
RA4811       25677           0      0.41938E+09
RA4812       25676       25677      0.53870E-02
VA4812       25675       25676 AC   0.00000E+00
LA4812       25674       25675      0.23489E-09
CA4813       25680           0      0.15706E-14
RA4813       25680           0      0.41938E+09
RA4814       25679       25680      0.53870E-02
VA4814       25678       25679 AC   0.00000E+00
LA4814       25677       25678      0.23489E-09
CA4815       25683           0      0.15706E-14
RA4815       25683           0      0.41938E+09
RA4816       25682       25683      0.53870E-02
VA4816       25681       25682 AC   0.00000E+00
LA4816       25680       25681      0.23489E-09
CA4817       25686           0      0.15706E-14
RA4817       25686           0      0.41938E+09
RA4818       25685       25686      0.53870E-02
VA4818       25684       25685 AC   0.00000E+00
LA4818       25683       25684      0.23489E-09
CA4819       25689           0      0.15706E-14
RA4819       25689           0      0.41938E+09
RA4820       25688       25689      0.53870E-02
VA4820       25687       25688 AC   0.00000E+00
LA4820       25686       25687      0.23489E-09
CA4821       25692           0      0.15706E-14
RA4821       25692           0      0.41938E+09
RA4822       25691       25692      0.53870E-02
VA4822       25690       25691 AC   0.00000E+00
LA4822       25689       25690      0.23489E-09
CA4823       25695           0      0.16556E-14
RA4823       25695           0      0.41938E+09
RA4824       25694       25695      0.53870E-02
VA4824       25693       25694 AC   0.00000E+00
LA4824       25692       25693      0.22302E-09
CA4825       25698           0      0.16556E-14
RA4825       25698           0      0.41938E+09
RA4826       25697       25698      0.53870E-02
VA4826       25696       25697 AC   0.00000E+00
LA4826       25695       25696      0.21116E-09
CA4827       25701           0      0.16556E-14
RA4827       25701           0      0.41938E+09
RA4828       25700       25701      0.53870E-02
VA4828       25699       25700 AC   0.00000E+00
LA4828       25698       25699      0.21116E-09
CA4829       25704           0      0.16556E-14
RA4829       25704           0      0.41938E+09
RA4830       25703       25704      0.53870E-02
VA4830       25702       25703 AC   0.00000E+00
LA4830       25701       25702      0.21116E-09
CA4831       25707           0      0.16556E-14
RA4831       25707           0      0.41938E+09
RA4832       25706       25707      0.53870E-02
VA4832       25705       25706 AC   0.00000E+00
LA4832       25704       25705      0.21116E-09
CA4833       25710           0      0.16556E-14
RA4833       25710           0      0.41938E+09
RA4834       25709       25710      0.53870E-02
VA4834       25708       25709 AC   0.00000E+00
LA4834       25707       25708      0.21116E-09
CA4835       25713           0      0.16556E-14
RA4835       25713           0      0.41938E+09
RA4836       25712       25713      0.53870E-02
VA4836       25711       25712 AC   0.00000E+00
LA4836       25710       25711      0.21116E-09
CA4837       25716           0      0.16556E-14
RA4837       25716           0      0.41938E+09
RA4838       25715       25716      0.53870E-02
VA4838       25714       25715 AC   0.00000E+00
LA4838       25713       25714      0.21116E-09
CA4839       25719           0      0.16556E-14
RA4839       25719           0      0.41938E+09
RA4840       25718       25719      0.53870E-02
VA4840       25717       25718 AC   0.00000E+00
LA4840       25716       25717      0.21116E-09
CA4841       25722           0      0.16556E-14
RA4841       25722           0      0.41938E+09
RA4842       25721       25722      0.53870E-02
VA4842       25720       25721 AC   0.00000E+00
LA4842       25719       25720      0.21116E-09
CA4843       25725           0      0.16556E-14
RA4843       25725           0      0.41938E+09
RA4844       25724       25725      0.53870E-02
VA4844       25723       25724 AC   0.00000E+00
LA4844       25722       25723      0.21116E-09
CA4845       25728           0      0.16556E-14
RA4845       25728           0      0.41938E+09
RA4846       25727       25728      0.53870E-02
VA4846       25726       25727 AC   0.00000E+00
LA4846       25725       25726      0.21116E-09
CA4847       25731           0      0.16556E-14
RA4847       25731           0      0.41938E+09
RA4848       25730       25731      0.53870E-02
VA4848       25729       25730 AC   0.00000E+00
LA4848       25728       25729      0.21116E-09
CA4849       25734           0      0.17352E-14
RA4849       25734           0      0.41938E+09
RA4850       25733       25734      0.53870E-02
VA4850       25732       25733 AC   0.00000E+00
LA4850       25731       25732      0.21116E-09
RA4851       25736       20141      0.53870E-02
VA4851       25735       25736 AC   0.00000E+00
LA4851       20003       25735      0.12767E-08
RA4852       25738       20144      0.53870E-02
VA4852       25737       25738 AC   0.00000E+00
LA4852       20006       25737      0.12767E-08
RA4853       25740       20147      0.53870E-02
VA4853       25739       25740 AC   0.00000E+00
LA4853       20009       25739      0.12767E-08
RA4854       25742       20150      0.53870E-02
VA4854       25741       25742 AC   0.00000E+00
LA4854       20012       25741      0.12767E-08
RA4855       25744       20153      0.53870E-02
VA4855       25743       25744 AC   0.00000E+00
LA4855       20015       25743      0.12767E-08
RA4856       25746       20156      0.53870E-02
VA4856       25745       25746 AC   0.00000E+00
LA4856       20018       25745      0.12767E-08
RA4857       25748       20159      0.53870E-02
VA4857       25747       25748 AC   0.00000E+00
LA4857       20021       25747      0.12767E-08
RA4858       25750       20162      0.53870E-02
VA4858       25749       25750 AC   0.00000E+00
LA4858       20024       25749      0.12767E-08
RA4859       25752       20165      0.53870E-02
VA4859       25751       25752 AC   0.00000E+00
LA4859       20027       25751      0.12767E-08
RA4860       25754       20168      0.53870E-02
VA4860       25753       25754 AC   0.00000E+00
LA4860       20030       25753      0.12767E-08
RA4861       25756       20171      0.53870E-02
VA4861       25755       25756 AC   0.00000E+00
LA4861       20033       25755      0.12767E-08
RA4862       25758       20174      0.53870E-02
VA4862       25757       25758 AC   0.00000E+00
LA4862       20036       25757      0.12767E-08
RA4863       25760       20177      0.53870E-02
VA4863       25759       25760 AC   0.00000E+00
LA4863       20039       25759      0.12767E-08
RA4864       25762       20180      0.53870E-02
VA4864       25761       25762 AC   0.00000E+00
LA4864       20042       25761      0.12767E-08
RA4865       25764       20183      0.53870E-02
VA4865       25763       25764 AC   0.00000E+00
LA4865       20045       25763      0.12767E-08
RA4866       25766       20186      0.53870E-02
VA4866       25765       25766 AC   0.00000E+00
LA4866       20048       25765      0.12767E-08
RA4867       25768       20189      0.53870E-02
VA4867       25767       25768 AC   0.00000E+00
LA4867       20051       25767      0.12767E-08
RA4868       25770       20192      0.53870E-02
VA4868       25769       25770 AC   0.00000E+00
LA4868       20054       25769      0.12767E-08
RA4869       25772       20195      0.53870E-02
VA4869       25771       25772 AC   0.00000E+00
LA4869       20057       25771      0.12767E-08
RA4870       25774       20198      0.53870E-02
VA4870       25773       25774 AC   0.00000E+00
LA4870       20060       25773      0.12767E-08
RA4871       25776       20201      0.53870E-02
VA4871       25775       25776 AC   0.00000E+00
LA4871       20063       25775      0.12767E-08
RA4872       25778       20204      0.53870E-02
VA4872       25777       25778 AC   0.00000E+00
LA4872       20066       25777      0.12767E-08
RA4873       25780       20207      0.53870E-02
VA4873       25779       25780 AC   0.00000E+00
LA4873       20069       25779      0.12767E-08
RA4874       25782       20210      0.53870E-02
VA4874       25781       25782 AC   0.00000E+00
LA4874       20072       25781      0.12767E-08
RA4875       25784       20213      0.53870E-02
VA4875       25783       25784 AC   0.00000E+00
LA4875       20075       25783      0.12767E-08
RA4876       25786       20216      0.53870E-02
VA4876       25785       25786 AC   0.00000E+00
LA4876       20078       25785      0.12767E-08
RA4877       25788       20219      0.53870E-02
VA4877       25787       25788 AC   0.00000E+00
LA4877       20081       25787      0.12767E-08
RA4878       25790       20222      0.53870E-02
VA4878       25789       25790 AC   0.00000E+00
LA4878       20084       25789      0.12767E-08
RA4879       25792       20225      0.53870E-02
VA4879       25791       25792 AC   0.00000E+00
LA4879       20087       25791      0.12767E-08
RA4880       25794       20228      0.53870E-02
VA4880       25793       25794 AC   0.00000E+00
LA4880       20090       25793      0.12767E-08
RA4881       25796       20231      0.53870E-02
VA4881       25795       25796 AC   0.00000E+00
LA4881       20093       25795      0.12767E-08
RA4882       25798       20234      0.53870E-02
VA4882       25797       25798 AC   0.00000E+00
LA4882       20096       25797      0.12767E-08
RA4883       25800       20237      0.53870E-02
VA4883       25799       25800 AC   0.00000E+00
LA4883       20099       25799      0.12767E-08
RA4884       25802       20240      0.53870E-02
VA4884       25801       25802 AC   0.00000E+00
LA4884       20102       25801      0.12767E-08
RA4885       25804       20243      0.53870E-02
VA4885       25803       25804 AC   0.00000E+00
LA4885       20105       25803      0.12767E-08
RA4886       25806       20246      0.53870E-02
VA4886       25805       25806 AC   0.00000E+00
LA4886       20108       25805      0.12767E-08
RA4887       25808       20249      0.53870E-02
VA4887       25807       25808 AC   0.00000E+00
LA4887       20111       25807      0.12767E-08
RA4888       25810       20252      0.53870E-02
VA4888       25809       25810 AC   0.00000E+00
LA4888       20114       25809      0.12767E-08
RA4889       25812       20255      0.53870E-02
VA4889       25811       25812 AC   0.00000E+00
LA4889       20117       25811      0.12767E-08
RA4890       25814       20258      0.53870E-02
VA4890       25813       25814 AC   0.00000E+00
LA4890       20120       25813      0.12767E-08
RA4891       25816       20261      0.53870E-02
VA4891       25815       25816 AC   0.00000E+00
LA4891       20123       25815      0.12767E-08
RA4892       25818       20264      0.53870E-02
VA4892       25817       25818 AC   0.00000E+00
LA4892       20126       25817      0.12767E-08
RA4893       25820       20267      0.53870E-02
VA4893       25819       25820 AC   0.00000E+00
LA4893       20129       25819      0.12767E-08
RA4894       25822       20270      0.53870E-02
VA4894       25821       25822 AC   0.00000E+00
LA4894       20132       25821      0.12767E-08
RA4895       25824       20273      0.53870E-02
VA4895       25823       25824 AC   0.00000E+00
LA4895       20135       25823      0.12767E-08
RA4896       25826       20276      0.53870E-02
VA4896       25825       25826 AC   0.00000E+00
LA4896       20138       25825      0.17730E-09
RA4897       25828       20279      0.53870E-02
VA4897       25827       25828 AC   0.00000E+00
LA4897       20141       25827      0.12767E-08
RA4898       25830       20282      0.53870E-02
VA4898       25829       25830 AC   0.00000E+00
LA4898       20144       25829      0.12767E-08
RA4899       25832       20285      0.53870E-02
VA4899       25831       25832 AC   0.00000E+00
LA4899       20147       25831      0.12767E-08
RA4900       25834       20288      0.53870E-02
VA4900       25833       25834 AC   0.00000E+00
LA4900       20150       25833      0.12767E-08
RA4901       25836       20291      0.53870E-02
VA4901       25835       25836 AC   0.00000E+00
LA4901       20153       25835      0.12767E-08
RA4902       25838       20294      0.53870E-02
VA4902       25837       25838 AC   0.00000E+00
LA4902       20156       25837      0.12767E-08
RA4903       25840       20297      0.53870E-02
VA4903       25839       25840 AC   0.00000E+00
LA4903       20159       25839      0.12767E-08
RA4904       25842       20300      0.53870E-02
VA4904       25841       25842 AC   0.00000E+00
LA4904       20162       25841      0.12767E-08
RA4905       25844       20303      0.53870E-02
VA4905       25843       25844 AC   0.00000E+00
LA4905       20165       25843      0.12767E-08
RA4906       25846       20306      0.53870E-02
VA4906       25845       25846 AC   0.00000E+00
LA4906       20168       25845      0.12767E-08
RA4907       25848       20309      0.53870E-02
VA4907       25847       25848 AC   0.00000E+00
LA4907       20171       25847      0.12767E-08
RA4908       25850       20312      0.53870E-02
VA4908       25849       25850 AC   0.00000E+00
LA4908       20174       25849      0.12767E-08
RA4909       25852       20315      0.53870E-02
VA4909       25851       25852 AC   0.00000E+00
LA4909       20177       25851      0.12767E-08
RA4910       25854       20318      0.53870E-02
VA4910       25853       25854 AC   0.00000E+00
LA4910       20180       25853      0.12767E-08
RA4911       25856       20321      0.53870E-02
VA4911       25855       25856 AC   0.00000E+00
LA4911       20183       25855      0.12767E-08
RA4912       25858       20324      0.53870E-02
VA4912       25857       25858 AC   0.00000E+00
LA4912       20186       25857      0.12767E-08
RA4913       25860       20327      0.53870E-02
VA4913       25859       25860 AC   0.00000E+00
LA4913       20189       25859      0.12767E-08
RA4914       25862       20330      0.53870E-02
VA4914       25861       25862 AC   0.00000E+00
LA4914       20192       25861      0.12767E-08
RA4915       25864       20333      0.53870E-02
VA4915       25863       25864 AC   0.00000E+00
LA4915       20195       25863      0.12767E-08
RA4916       25866       20336      0.53870E-02
VA4916       25865       25866 AC   0.00000E+00
LA4916       20198       25865      0.12767E-08
RA4917       25868       20339      0.53870E-02
VA4917       25867       25868 AC   0.00000E+00
LA4917       20201       25867      0.12767E-08
RA4918       25870       20342      0.53870E-02
VA4918       25869       25870 AC   0.00000E+00
LA4918       20204       25869      0.12767E-08
RA4919       25872       20345      0.53870E-02
VA4919       25871       25872 AC   0.00000E+00
LA4919       20207       25871      0.12767E-08
RA4920       25874       20348      0.53870E-02
VA4920       25873       25874 AC   0.00000E+00
LA4920       20210       25873      0.12767E-08
RA4921       25876       20351      0.53870E-02
VA4921       25875       25876 AC   0.00000E+00
LA4921       20213       25875      0.12767E-08
RA4922       25878       20354      0.53870E-02
VA4922       25877       25878 AC   0.00000E+00
LA4922       20216       25877      0.12767E-08
RA4923       25880       20357      0.53870E-02
VA4923       25879       25880 AC   0.00000E+00
LA4923       20219       25879      0.12767E-08
RA4924       25882       20360      0.53870E-02
VA4924       25881       25882 AC   0.00000E+00
LA4924       20222       25881      0.12767E-08
RA4925       25884       20363      0.53870E-02
VA4925       25883       25884 AC   0.00000E+00
LA4925       20225       25883      0.12767E-08
RA4926       25886       20366      0.53870E-02
VA4926       25885       25886 AC   0.00000E+00
LA4926       20228       25885      0.12767E-08
RA4927       25888       20369      0.53870E-02
VA4927       25887       25888 AC   0.00000E+00
LA4927       20231       25887      0.12767E-08
RA4928       25890       20372      0.53870E-02
VA4928       25889       25890 AC   0.00000E+00
LA4928       20234       25889      0.12767E-08
RA4929       25892       20375      0.53870E-02
VA4929       25891       25892 AC   0.00000E+00
LA4929       20237       25891      0.12767E-08
RA4930       25894       20378      0.53870E-02
VA4930       25893       25894 AC   0.00000E+00
LA4930       20240       25893      0.12767E-08
RA4931       25896       20381      0.53870E-02
VA4931       25895       25896 AC   0.00000E+00
LA4931       20243       25895      0.12767E-08
RA4932       25898       20384      0.53870E-02
VA4932       25897       25898 AC   0.00000E+00
LA4932       20246       25897      0.12767E-08
RA4933       25900       20387      0.53870E-02
VA4933       25899       25900 AC   0.00000E+00
LA4933       20249       25899      0.12767E-08
RA4934       25902       20390      0.53870E-02
VA4934       25901       25902 AC   0.00000E+00
LA4934       20252       25901      0.12767E-08
RA4935       25904       20393      0.53870E-02
VA4935       25903       25904 AC   0.00000E+00
LA4935       20255       25903      0.12767E-08
RA4936       25906       20396      0.53870E-02
VA4936       25905       25906 AC   0.00000E+00
LA4936       20258       25905      0.12767E-08
RA4937       25908       20399      0.53870E-02
VA4937       25907       25908 AC   0.00000E+00
LA4937       20261       25907      0.12767E-08
RA4938       25910       20402      0.53870E-02
VA4938       25909       25910 AC   0.00000E+00
LA4938       20264       25909      0.12767E-08
RA4939       25912       20405      0.53870E-02
VA4939       25911       25912 AC   0.00000E+00
LA4939       20267       25911      0.12767E-08
RA4940       25914       20408      0.53870E-02
VA4940       25913       25914 AC   0.00000E+00
LA4940       20270       25913      0.12767E-08
RA4941       25916       20411      0.53870E-02
VA4941       25915       25916 AC   0.00000E+00
LA4941       20273       25915      0.12767E-08
RA4942       25918       20414      0.53870E-02
VA4942       25917       25918 AC   0.00000E+00
LA4942       20276       25917      0.17730E-09
RA4943       25920       20417      0.53870E-02
VA4943       25919       25920 AC   0.00000E+00
LA4943       20279       25919      0.12767E-08
RA4944       25922       20420      0.53870E-02
VA4944       25921       25922 AC   0.00000E+00
LA4944       20282       25921      0.12767E-08
RA4945       25924       20423      0.53870E-02
VA4945       25923       25924 AC   0.00000E+00
LA4945       20285       25923      0.12767E-08
RA4946       25926       20426      0.53870E-02
VA4946       25925       25926 AC   0.00000E+00
LA4946       20288       25925      0.12767E-08
RA4947       25928       20429      0.53870E-02
VA4947       25927       25928 AC   0.00000E+00
LA4947       20291       25927      0.12767E-08
RA4948       25930       20432      0.53870E-02
VA4948       25929       25930 AC   0.00000E+00
LA4948       20294       25929      0.12767E-08
RA4949       25932       20435      0.53870E-02
VA4949       25931       25932 AC   0.00000E+00
LA4949       20297       25931      0.12767E-08
RA4950       25934       20438      0.53870E-02
VA4950       25933       25934 AC   0.00000E+00
LA4950       20300       25933      0.12767E-08
RA4951       25936       20441      0.53870E-02
VA4951       25935       25936 AC   0.00000E+00
LA4951       20303       25935      0.12767E-08
RA4952       25938       20444      0.53870E-02
VA4952       25937       25938 AC   0.00000E+00
LA4952       20306       25937      0.12767E-08
RA4953       25940       20447      0.53870E-02
VA4953       25939       25940 AC   0.00000E+00
LA4953       20309       25939      0.12767E-08
RA4954       25942       20450      0.53870E-02
VA4954       25941       25942 AC   0.00000E+00
LA4954       20312       25941      0.12767E-08
RA4955       25944       20453      0.53870E-02
VA4955       25943       25944 AC   0.00000E+00
LA4955       20315       25943      0.12767E-08
RA4956       25946       20456      0.53870E-02
VA4956       25945       25946 AC   0.00000E+00
LA4956       20318       25945      0.12767E-08
RA4957       25948       20459      0.53870E-02
VA4957       25947       25948 AC   0.00000E+00
LA4957       20321       25947      0.12767E-08
RA4958       25950       20462      0.53870E-02
VA4958       25949       25950 AC   0.00000E+00
LA4958       20324       25949      0.12767E-08
RA4959       25952       20465      0.53870E-02
VA4959       25951       25952 AC   0.00000E+00
LA4959       20327       25951      0.12767E-08
RA4960       25954       20468      0.53870E-02
VA4960       25953       25954 AC   0.00000E+00
LA4960       20330       25953      0.12767E-08
RA4961       25956       20471      0.53870E-02
VA4961       25955       25956 AC   0.00000E+00
LA4961       20333       25955      0.12767E-08
RA4962       25958       20474      0.53870E-02
VA4962       25957       25958 AC   0.00000E+00
LA4962       20336       25957      0.12767E-08
RA4963       25960       20477      0.53870E-02
VA4963       25959       25960 AC   0.00000E+00
LA4963       20339       25959      0.12767E-08
RA4964       25962       20480      0.53870E-02
VA4964       25961       25962 AC   0.00000E+00
LA4964       20342       25961      0.12767E-08
RA4965       25964       20483      0.53870E-02
VA4965       25963       25964 AC   0.00000E+00
LA4965       20345       25963      0.12767E-08
RA4966       25966       20486      0.53870E-02
VA4966       25965       25966 AC   0.00000E+00
LA4966       20348       25965      0.12767E-08
RA4967       25968       20489      0.53870E-02
VA4967       25967       25968 AC   0.00000E+00
LA4967       20351       25967      0.12767E-08
RA4968       25970       20492      0.53870E-02
VA4968       25969       25970 AC   0.00000E+00
LA4968       20354       25969      0.12767E-08
RA4969       25972       20495      0.53870E-02
VA4969       25971       25972 AC   0.00000E+00
LA4969       20357       25971      0.12767E-08
RA4970       25974       20498      0.53870E-02
VA4970       25973       25974 AC   0.00000E+00
LA4970       20360       25973      0.12767E-08
RA4971       25976       20501      0.53870E-02
VA4971       25975       25976 AC   0.00000E+00
LA4971       20363       25975      0.12767E-08
RA4972       25978       20504      0.53870E-02
VA4972       25977       25978 AC   0.00000E+00
LA4972       20366       25977      0.12767E-08
RA4973       25980       20507      0.53870E-02
VA4973       25979       25980 AC   0.00000E+00
LA4973       20369       25979      0.12767E-08
RA4974       25982       20510      0.53870E-02
VA4974       25981       25982 AC   0.00000E+00
LA4974       20372       25981      0.12767E-08
RA4975       25984       20513      0.53870E-02
VA4975       25983       25984 AC   0.00000E+00
LA4975       20375       25983      0.12767E-08
RA4976       25986       20516      0.53870E-02
VA4976       25985       25986 AC   0.00000E+00
LA4976       20378       25985      0.12767E-08
RA4977       25988       20519      0.53870E-02
VA4977       25987       25988 AC   0.00000E+00
LA4977       20381       25987      0.12767E-08
RA4978       25990       20522      0.53870E-02
VA4978       25989       25990 AC   0.00000E+00
LA4978       20384       25989      0.12767E-08
RA4979       25992       20525      0.53870E-02
VA4979       25991       25992 AC   0.00000E+00
LA4979       20387       25991      0.12767E-08
RA4980       25994       20528      0.53870E-02
VA4980       25993       25994 AC   0.00000E+00
LA4980       20390       25993      0.12767E-08
RA4981       25996       20531      0.53870E-02
VA4981       25995       25996 AC   0.00000E+00
LA4981       20393       25995      0.12767E-08
RA4982       25998       20534      0.53870E-02
VA4982       25997       25998 AC   0.00000E+00
LA4982       20396       25997      0.12767E-08
RA4983       26000       20537      0.53870E-02
VA4983       25999       26000 AC   0.00000E+00
LA4983       20399       25999      0.12767E-08
RA4984       26002       20540      0.53870E-02
VA4984       26001       26002 AC   0.00000E+00
LA4984       20402       26001      0.12767E-08
RA4985       26004       20543      0.53870E-02
VA4985       26003       26004 AC   0.00000E+00
LA4985       20405       26003      0.12767E-08
RA4986       26006       20546      0.53870E-02
VA4986       26005       26006 AC   0.00000E+00
LA4986       20408       26005      0.12767E-08
RA4987       26008       20549      0.53870E-02
VA4987       26007       26008 AC   0.00000E+00
LA4987       20411       26007      0.12767E-08
RA4988       26010       20552      0.53870E-02
VA4988       26009       26010 AC   0.00000E+00
LA4988       20414       26009      0.17730E-09
RA4989       26012       20555      0.53870E-02
VA4989       26011       26012 AC   0.00000E+00
LA4989       20417       26011      0.12767E-08
RA4990       26014       20558      0.53870E-02
VA4990       26013       26014 AC   0.00000E+00
LA4990       20420       26013      0.12767E-08
RA4991       26016       20561      0.53870E-02
VA4991       26015       26016 AC   0.00000E+00
LA4991       20423       26015      0.12767E-08
RA4992       26018       20564      0.53870E-02
VA4992       26017       26018 AC   0.00000E+00
LA4992       20426       26017      0.12767E-08
RA4993       26020       20567      0.53870E-02
VA4993       26019       26020 AC   0.00000E+00
LA4993       20429       26019      0.12767E-08
RA4994       26022       20570      0.53870E-02
VA4994       26021       26022 AC   0.00000E+00
LA4994       20432       26021      0.12767E-08
RA4995       26024       20573      0.53870E-02
VA4995       26023       26024 AC   0.00000E+00
LA4995       20435       26023      0.12767E-08
RA4996       26026       20576      0.53870E-02
VA4996       26025       26026 AC   0.00000E+00
LA4996       20438       26025      0.12767E-08
RA4997       26028       20579      0.53870E-02
VA4997       26027       26028 AC   0.00000E+00
LA4997       20441       26027      0.12767E-08
RA4998       26030       20582      0.53870E-02
VA4998       26029       26030 AC   0.00000E+00
LA4998       20444       26029      0.12767E-08
RA4999       26032       20585      0.53870E-02
VA4999       26031       26032 AC   0.00000E+00
LA4999       20447       26031      0.12767E-08
RA5000       26034       20588      0.53870E-02
VA5000       26033       26034 AC   0.00000E+00
LA5000       20450       26033      0.12767E-08
RA5001       26036       20591      0.53870E-02
VA5001       26035       26036 AC   0.00000E+00
LA5001       20453       26035      0.12767E-08
RA5002       26038       20594      0.53870E-02
VA5002       26037       26038 AC   0.00000E+00
LA5002       20456       26037      0.12767E-08
RA5003       26040       20597      0.53870E-02
VA5003       26039       26040 AC   0.00000E+00
LA5003       20459       26039      0.12767E-08
RA5004       26042       20600      0.53870E-02
VA5004       26041       26042 AC   0.00000E+00
LA5004       20462       26041      0.12767E-08
RA5005       26044       20603      0.53870E-02
VA5005       26043       26044 AC   0.00000E+00
LA5005       20465       26043      0.12767E-08
RA5006       26046       20606      0.53870E-02
VA5006       26045       26046 AC   0.00000E+00
LA5006       20468       26045      0.12767E-08
RA5007       26048       20609      0.53870E-02
VA5007       26047       26048 AC   0.00000E+00
LA5007       20471       26047      0.12767E-08
RA5008       26050       20612      0.53870E-02
VA5008       26049       26050 AC   0.00000E+00
LA5008       20474       26049      0.12767E-08
RA5009       26052       20615      0.53870E-02
VA5009       26051       26052 AC   0.00000E+00
LA5009       20477       26051      0.12767E-08
RA5010       26054       20618      0.53870E-02
VA5010       26053       26054 AC   0.00000E+00
LA5010       20480       26053      0.12767E-08
RA5011       26056       20621      0.53870E-02
VA5011       26055       26056 AC   0.00000E+00
LA5011       20483       26055      0.12767E-08
RA5012       26058       20624      0.53870E-02
VA5012       26057       26058 AC   0.00000E+00
LA5012       20486       26057      0.12767E-08
RA5013       26060       20627      0.53870E-02
VA5013       26059       26060 AC   0.00000E+00
LA5013       20489       26059      0.12767E-08
RA5014       26062       20630      0.53870E-02
VA5014       26061       26062 AC   0.00000E+00
LA5014       20492       26061      0.12767E-08
RA5015       26064       20633      0.53870E-02
VA5015       26063       26064 AC   0.00000E+00
LA5015       20495       26063      0.12767E-08
RA5016       26066       20636      0.53870E-02
VA5016       26065       26066 AC   0.00000E+00
LA5016       20498       26065      0.12767E-08
RA5017       26068       20639      0.53870E-02
VA5017       26067       26068 AC   0.00000E+00
LA5017       20501       26067      0.12767E-08
RA5018       26070       20642      0.53870E-02
VA5018       26069       26070 AC   0.00000E+00
LA5018       20504       26069      0.12767E-08
RA5019       26072       20645      0.53870E-02
VA5019       26071       26072 AC   0.00000E+00
LA5019       20507       26071      0.12767E-08
RA5020       26074       20648      0.53870E-02
VA5020       26073       26074 AC   0.00000E+00
LA5020       20510       26073      0.12767E-08
RA5021       26076       20651      0.53870E-02
VA5021       26075       26076 AC   0.00000E+00
LA5021       20513       26075      0.12767E-08
RA5022       26078       20654      0.53870E-02
VA5022       26077       26078 AC   0.00000E+00
LA5022       20516       26077      0.12767E-08
RA5023       26080       20657      0.53870E-02
VA5023       26079       26080 AC   0.00000E+00
LA5023       20519       26079      0.12767E-08
RA5024       26082       20660      0.53870E-02
VA5024       26081       26082 AC   0.00000E+00
LA5024       20522       26081      0.12767E-08
RA5025       26084       20663      0.53870E-02
VA5025       26083       26084 AC   0.00000E+00
LA5025       20525       26083      0.12767E-08
RA5026       26086       20666      0.53870E-02
VA5026       26085       26086 AC   0.00000E+00
LA5026       20528       26085      0.12767E-08
RA5027       26088       20669      0.53870E-02
VA5027       26087       26088 AC   0.00000E+00
LA5027       20531       26087      0.12767E-08
RA5028       26090       20672      0.53870E-02
VA5028       26089       26090 AC   0.00000E+00
LA5028       20534       26089      0.12767E-08
RA5029       26092       20675      0.53870E-02
VA5029       26091       26092 AC   0.00000E+00
LA5029       20537       26091      0.12767E-08
RA5030       26094       20678      0.53870E-02
VA5030       26093       26094 AC   0.00000E+00
LA5030       20540       26093      0.12767E-08
RA5031       26096       20681      0.53870E-02
VA5031       26095       26096 AC   0.00000E+00
LA5031       20543       26095      0.12767E-08
RA5032       26098       20684      0.53870E-02
VA5032       26097       26098 AC   0.00000E+00
LA5032       20546       26097      0.12767E-08
RA5033       26100       20687      0.53870E-02
VA5033       26099       26100 AC   0.00000E+00
LA5033       20549       26099      0.12767E-08
RA5034       26102       20690      0.53870E-02
VA5034       26101       26102 AC   0.00000E+00
LA5034       20552       26101      0.17730E-09
RA5035       26104       20693      0.53870E-02
VA5035       26103       26104 AC   0.00000E+00
LA5035       20555       26103      0.12767E-08
RA5036       26106       20696      0.53870E-02
VA5036       26105       26106 AC   0.00000E+00
LA5036       20558       26105      0.12767E-08
RA5037       26108       20699      0.53870E-02
VA5037       26107       26108 AC   0.00000E+00
LA5037       20561       26107      0.12767E-08
RA5038       26110       20702      0.53870E-02
VA5038       26109       26110 AC   0.00000E+00
LA5038       20564       26109      0.12767E-08
RA5039       26112       20705      0.53870E-02
VA5039       26111       26112 AC   0.00000E+00
LA5039       20567       26111      0.12767E-08
RA5040       26114       20708      0.53870E-02
VA5040       26113       26114 AC   0.00000E+00
LA5040       20570       26113      0.12767E-08
RA5041       26116       20711      0.53870E-02
VA5041       26115       26116 AC   0.00000E+00
LA5041       20573       26115      0.12767E-08
RA5042       26118       20714      0.53870E-02
VA5042       26117       26118 AC   0.00000E+00
LA5042       20576       26117      0.12767E-08
RA5043       26120       20717      0.53870E-02
VA5043       26119       26120 AC   0.00000E+00
LA5043       20579       26119      0.12767E-08
RA5044       26122       20720      0.53870E-02
VA5044       26121       26122 AC   0.00000E+00
LA5044       20582       26121      0.12767E-08
RA5045       26124       20723      0.53870E-02
VA5045       26123       26124 AC   0.00000E+00
LA5045       20585       26123      0.12767E-08
RA5046       26126       20726      0.53870E-02
VA5046       26125       26126 AC   0.00000E+00
LA5046       20588       26125      0.12767E-08
RA5047       26128       20729      0.53870E-02
VA5047       26127       26128 AC   0.00000E+00
LA5047       20591       26127      0.12767E-08
RA5048       26130       20732      0.53870E-02
VA5048       26129       26130 AC   0.00000E+00
LA5048       20594       26129      0.12767E-08
RA5049       26132       20735      0.53870E-02
VA5049       26131       26132 AC   0.00000E+00
LA5049       20597       26131      0.12767E-08
RA5050       26134       20738      0.53870E-02
VA5050       26133       26134 AC   0.00000E+00
LA5050       20600       26133      0.12767E-08
RA5051       26136       20741      0.53870E-02
VA5051       26135       26136 AC   0.00000E+00
LA5051       20603       26135      0.12767E-08
RA5052       26138       20744      0.53870E-02
VA5052       26137       26138 AC   0.00000E+00
LA5052       20606       26137      0.12767E-08
RA5053       26140       20747      0.53870E-02
VA5053       26139       26140 AC   0.00000E+00
LA5053       20609       26139      0.12767E-08
RA5054       26142       20750      0.53870E-02
VA5054       26141       26142 AC   0.00000E+00
LA5054       20612       26141      0.12767E-08
RA5055       26144       20753      0.53870E-02
VA5055       26143       26144 AC   0.00000E+00
LA5055       20615       26143      0.12767E-08
RA5056       26146       20756      0.53870E-02
VA5056       26145       26146 AC   0.00000E+00
LA5056       20618       26145      0.12767E-08
RA5057       26148       20759      0.53870E-02
VA5057       26147       26148 AC   0.00000E+00
LA5057       20621       26147      0.12767E-08
RA5058       26150       20762      0.53870E-02
VA5058       26149       26150 AC   0.00000E+00
LA5058       20624       26149      0.12767E-08
RA5059       26152       20765      0.53870E-02
VA5059       26151       26152 AC   0.00000E+00
LA5059       20627       26151      0.12767E-08
RA5060       26154       20768      0.53870E-02
VA5060       26153       26154 AC   0.00000E+00
LA5060       20630       26153      0.12767E-08
RA5061       26156       20771      0.53870E-02
VA5061       26155       26156 AC   0.00000E+00
LA5061       20633       26155      0.12767E-08
RA5062       26158       20774      0.53870E-02
VA5062       26157       26158 AC   0.00000E+00
LA5062       20636       26157      0.12767E-08
RA5063       26160       20777      0.53870E-02
VA5063       26159       26160 AC   0.00000E+00
LA5063       20639       26159      0.12767E-08
RA5064       26162       20780      0.53870E-02
VA5064       26161       26162 AC   0.00000E+00
LA5064       20642       26161      0.12767E-08
RA5065       26164       20783      0.53870E-02
VA5065       26163       26164 AC   0.00000E+00
LA5065       20645       26163      0.12767E-08
RA5066       26166       20786      0.53870E-02
VA5066       26165       26166 AC   0.00000E+00
LA5066       20648       26165      0.12767E-08
RA5067       26168       20789      0.53870E-02
VA5067       26167       26168 AC   0.00000E+00
LA5067       20651       26167      0.12767E-08
RA5068       26170       20792      0.53870E-02
VA5068       26169       26170 AC   0.00000E+00
LA5068       20654       26169      0.12767E-08
RA5069       26172       20795      0.53870E-02
VA5069       26171       26172 AC   0.00000E+00
LA5069       20657       26171      0.12767E-08
RA5070       26174       20798      0.53870E-02
VA5070       26173       26174 AC   0.00000E+00
LA5070       20660       26173      0.12767E-08
RA5071       26176       20801      0.53870E-02
VA5071       26175       26176 AC   0.00000E+00
LA5071       20663       26175      0.12767E-08
RA5072       26178       20804      0.53870E-02
VA5072       26177       26178 AC   0.00000E+00
LA5072       20666       26177      0.12767E-08
RA5073       26180       20807      0.53870E-02
VA5073       26179       26180 AC   0.00000E+00
LA5073       20669       26179      0.12767E-08
RA5074       26182       20810      0.53870E-02
VA5074       26181       26182 AC   0.00000E+00
LA5074       20672       26181      0.12767E-08
RA5075       26184       20813      0.53870E-02
VA5075       26183       26184 AC   0.00000E+00
LA5075       20675       26183      0.12767E-08
RA5076       26186       20816      0.53870E-02
VA5076       26185       26186 AC   0.00000E+00
LA5076       20678       26185      0.12767E-08
RA5077       26188       20819      0.53870E-02
VA5077       26187       26188 AC   0.00000E+00
LA5077       20681       26187      0.12767E-08
RA5078       26190       20822      0.53870E-02
VA5078       26189       26190 AC   0.00000E+00
LA5078       20684       26189      0.12767E-08
RA5079       26192       20825      0.53870E-02
VA5079       26191       26192 AC   0.00000E+00
LA5079       20687       26191      0.12767E-08
RA5080       26194       20828      0.53870E-02
VA5080       26193       26194 AC   0.00000E+00
LA5080       20690       26193      0.17730E-09
RA5081       26196       20831      0.53870E-02
VA5081       26195       26196 AC   0.00000E+00
LA5081       20693       26195      0.12767E-08
RA5082       26198       20834      0.53870E-02
VA5082       26197       26198 AC   0.00000E+00
LA5082       20696       26197      0.12767E-08
RA5083       26200       20837      0.53870E-02
VA5083       26199       26200 AC   0.00000E+00
LA5083       20699       26199      0.12767E-08
RA5084       26202       20840      0.53870E-02
VA5084       26201       26202 AC   0.00000E+00
LA5084       20702       26201      0.12767E-08
RA5085       26204       20843      0.53870E-02
VA5085       26203       26204 AC   0.00000E+00
LA5085       20705       26203      0.12767E-08
RA5086       26206       20846      0.53870E-02
VA5086       26205       26206 AC   0.00000E+00
LA5086       20708       26205      0.12767E-08
RA5087       26208       20849      0.53870E-02
VA5087       26207       26208 AC   0.00000E+00
LA5087       20711       26207      0.12767E-08
RA5088       26210       20852      0.53870E-02
VA5088       26209       26210 AC   0.00000E+00
LA5088       20714       26209      0.12767E-08
RA5089       26212       20855      0.53870E-02
VA5089       26211       26212 AC   0.00000E+00
LA5089       20717       26211      0.12767E-08
RA5090       26214       20858      0.53870E-02
VA5090       26213       26214 AC   0.00000E+00
LA5090       20720       26213      0.12767E-08
RA5091       26216       20861      0.53870E-02
VA5091       26215       26216 AC   0.00000E+00
LA5091       20723       26215      0.12767E-08
RA5092       26218       20864      0.53870E-02
VA5092       26217       26218 AC   0.00000E+00
LA5092       20726       26217      0.12767E-08
RA5093       26220       20867      0.53870E-02
VA5093       26219       26220 AC   0.00000E+00
LA5093       20729       26219      0.12767E-08
RA5094       26222       20870      0.53870E-02
VA5094       26221       26222 AC   0.00000E+00
LA5094       20732       26221      0.12767E-08
RA5095       26224       20873      0.53870E-02
VA5095       26223       26224 AC   0.00000E+00
LA5095       20735       26223      0.12767E-08
RA5096       26226       20876      0.53870E-02
VA5096       26225       26226 AC   0.00000E+00
LA5096       20738       26225      0.12767E-08
RA5097       26228       20879      0.53870E-02
VA5097       26227       26228 AC   0.00000E+00
LA5097       20741       26227      0.12767E-08
RA5098       26230       20882      0.53870E-02
VA5098       26229       26230 AC   0.00000E+00
LA5098       20744       26229      0.12767E-08
RA5099       26232       20885      0.53870E-02
VA5099       26231       26232 AC   0.00000E+00
LA5099       20747       26231      0.12767E-08
RA5100       26234       20888      0.53870E-02
VA5100       26233       26234 AC   0.00000E+00
LA5100       20750       26233      0.12767E-08
RA5101       26236       20891      0.53870E-02
VA5101       26235       26236 AC   0.00000E+00
LA5101       20753       26235      0.12767E-08
RA5102       26238       20894      0.53870E-02
VA5102       26237       26238 AC   0.00000E+00
LA5102       20756       26237      0.12767E-08
RA5103       26240       20897      0.53870E-02
VA5103       26239       26240 AC   0.00000E+00
LA5103       20759       26239      0.12767E-08
RA5104       26242       20900      0.53870E-02
VA5104       26241       26242 AC   0.00000E+00
LA5104       20762       26241      0.12767E-08
RA5105       26244       20903      0.53870E-02
VA5105       26243       26244 AC   0.00000E+00
LA5105       20765       26243      0.12767E-08
RA5106       26246       20906      0.53870E-02
VA5106       26245       26246 AC   0.00000E+00
LA5106       20768       26245      0.12767E-08
RA5107       26248       20909      0.53870E-02
VA5107       26247       26248 AC   0.00000E+00
LA5107       20771       26247      0.12767E-08
RA5108       26250       20912      0.53870E-02
VA5108       26249       26250 AC   0.00000E+00
LA5108       20774       26249      0.12767E-08
RA5109       26252       20915      0.53870E-02
VA5109       26251       26252 AC   0.00000E+00
LA5109       20777       26251      0.12767E-08
RA5110       26254       20918      0.53870E-02
VA5110       26253       26254 AC   0.00000E+00
LA5110       20780       26253      0.12767E-08
RA5111       26256       20921      0.53870E-02
VA5111       26255       26256 AC   0.00000E+00
LA5111       20783       26255      0.12767E-08
RA5112       26258       20924      0.53870E-02
VA5112       26257       26258 AC   0.00000E+00
LA5112       20786       26257      0.12767E-08
RA5113       26260       20927      0.53870E-02
VA5113       26259       26260 AC   0.00000E+00
LA5113       20789       26259      0.12767E-08
RA5114       26262       20930      0.53870E-02
VA5114       26261       26262 AC   0.00000E+00
LA5114       20792       26261      0.12767E-08
RA5115       26264       20933      0.53870E-02
VA5115       26263       26264 AC   0.00000E+00
LA5115       20795       26263      0.12767E-08
RA5116       26266       20936      0.53870E-02
VA5116       26265       26266 AC   0.00000E+00
LA5116       20798       26265      0.12767E-08
RA5117       26268       20939      0.53870E-02
VA5117       26267       26268 AC   0.00000E+00
LA5117       20801       26267      0.12767E-08
RA5118       26270       20942      0.53870E-02
VA5118       26269       26270 AC   0.00000E+00
LA5118       20804       26269      0.12767E-08
RA5119       26272       20945      0.53870E-02
VA5119       26271       26272 AC   0.00000E+00
LA5119       20807       26271      0.12767E-08
RA5120       26274       20948      0.53870E-02
VA5120       26273       26274 AC   0.00000E+00
LA5120       20810       26273      0.12767E-08
RA5121       26276       20951      0.53870E-02
VA5121       26275       26276 AC   0.00000E+00
LA5121       20813       26275      0.12767E-08
RA5122       26278       20954      0.53870E-02
VA5122       26277       26278 AC   0.00000E+00
LA5122       20816       26277      0.12767E-08
RA5123       26280       20957      0.53870E-02
VA5123       26279       26280 AC   0.00000E+00
LA5123       20819       26279      0.12767E-08
RA5124       26282       20960      0.53870E-02
VA5124       26281       26282 AC   0.00000E+00
LA5124       20822       26281      0.12767E-08
RA5125       26284       20963      0.53870E-02
VA5125       26283       26284 AC   0.00000E+00
LA5125       20825       26283      0.12767E-08
RA5126       26286       20966      0.53870E-02
VA5126       26285       26286 AC   0.00000E+00
LA5126       20828       26285      0.17730E-09
RA5127       26288       20969      0.53870E-02
VA5127       26287       26288 AC   0.00000E+00
LA5127       20831       26287      0.12767E-08
RA5128       26290       20972      0.53870E-02
VA5128       26289       26290 AC   0.00000E+00
LA5128       20834       26289      0.12767E-08
RA5129       26292       20975      0.53870E-02
VA5129       26291       26292 AC   0.00000E+00
LA5129       20837       26291      0.12767E-08
RA5130       26294       20978      0.53870E-02
VA5130       26293       26294 AC   0.00000E+00
LA5130       20840       26293      0.12767E-08
RA5131       26296       20981      0.53870E-02
VA5131       26295       26296 AC   0.00000E+00
LA5131       20843       26295      0.12767E-08
RA5132       26298       20984      0.53870E-02
VA5132       26297       26298 AC   0.00000E+00
LA5132       20846       26297      0.12767E-08
RA5133       26300       20987      0.53870E-02
VA5133       26299       26300 AC   0.00000E+00
LA5133       20849       26299      0.12767E-08
RA5134       26302       20990      0.53870E-02
VA5134       26301       26302 AC   0.00000E+00
LA5134       20852       26301      0.12767E-08
RA5135       26304       20993      0.53870E-02
VA5135       26303       26304 AC   0.00000E+00
LA5135       20855       26303      0.12767E-08
RA5136       26306       20996      0.53870E-02
VA5136       26305       26306 AC   0.00000E+00
LA5136       20858       26305      0.12767E-08
RA5137       26308       20999      0.53870E-02
VA5137       26307       26308 AC   0.00000E+00
LA5137       20861       26307      0.12767E-08
RA5138       26310       21002      0.53870E-02
VA5138       26309       26310 AC   0.00000E+00
LA5138       20864       26309      0.12767E-08
RA5139       26312       21005      0.53870E-02
VA5139       26311       26312 AC   0.00000E+00
LA5139       20867       26311      0.12767E-08
RA5140       26314       21008      0.53870E-02
VA5140       26313       26314 AC   0.00000E+00
LA5140       20870       26313      0.12767E-08
RA5141       26316       21011      0.53870E-02
VA5141       26315       26316 AC   0.00000E+00
LA5141       20873       26315      0.12767E-08
RA5142       26318       21014      0.53870E-02
VA5142       26317       26318 AC   0.00000E+00
LA5142       20876       26317      0.12767E-08
RA5143       26320       21017      0.53870E-02
VA5143       26319       26320 AC   0.00000E+00
LA5143       20879       26319      0.12767E-08
RA5144       26322       21020      0.53870E-02
VA5144       26321       26322 AC   0.00000E+00
LA5144       20882       26321      0.12767E-08
RA5145       26324       21023      0.53870E-02
VA5145       26323       26324 AC   0.00000E+00
LA5145       20885       26323      0.12767E-08
RA5146       26326       21026      0.53870E-02
VA5146       26325       26326 AC   0.00000E+00
LA5146       20888       26325      0.12767E-08
RA5147       26328       21029      0.53870E-02
VA5147       26327       26328 AC   0.00000E+00
LA5147       20891       26327      0.12767E-08
RA5148       26330       21032      0.53870E-02
VA5148       26329       26330 AC   0.00000E+00
LA5148       20894       26329      0.12767E-08
RA5149       26332       21035      0.53870E-02
VA5149       26331       26332 AC   0.00000E+00
LA5149       20897       26331      0.12767E-08
RA5150       26334       21038      0.53870E-02
VA5150       26333       26334 AC   0.00000E+00
LA5150       20900       26333      0.12767E-08
RA5151       26336       21041      0.53870E-02
VA5151       26335       26336 AC   0.00000E+00
LA5151       20903       26335      0.12767E-08
RA5152       26338       21044      0.53870E-02
VA5152       26337       26338 AC   0.00000E+00
LA5152       20906       26337      0.12767E-08
RA5153       26340       21047      0.53870E-02
VA5153       26339       26340 AC   0.00000E+00
LA5153       20909       26339      0.12767E-08
RA5154       26342       21050      0.53870E-02
VA5154       26341       26342 AC   0.00000E+00
LA5154       20912       26341      0.12767E-08
RA5155       26344       21053      0.53870E-02
VA5155       26343       26344 AC   0.00000E+00
LA5155       20915       26343      0.12767E-08
RA5156       26346       21056      0.53870E-02
VA5156       26345       26346 AC   0.00000E+00
LA5156       20918       26345      0.12767E-08
RA5157       26348       21059      0.53870E-02
VA5157       26347       26348 AC   0.00000E+00
LA5157       20921       26347      0.12767E-08
RA5158       26350       21062      0.53870E-02
VA5158       26349       26350 AC   0.00000E+00
LA5158       20924       26349      0.12767E-08
RA5159       26352       21065      0.53870E-02
VA5159       26351       26352 AC   0.00000E+00
LA5159       20927       26351      0.12767E-08
RA5160       26354       21068      0.53870E-02
VA5160       26353       26354 AC   0.00000E+00
LA5160       20930       26353      0.12767E-08
RA5161       26356       21071      0.53870E-02
VA5161       26355       26356 AC   0.00000E+00
LA5161       20933       26355      0.12767E-08
RA5162       26358       21074      0.53870E-02
VA5162       26357       26358 AC   0.00000E+00
LA5162       20936       26357      0.12767E-08
RA5163       26360       21077      0.53870E-02
VA5163       26359       26360 AC   0.00000E+00
LA5163       20939       26359      0.12767E-08
RA5164       26362       21080      0.53870E-02
VA5164       26361       26362 AC   0.00000E+00
LA5164       20942       26361      0.12767E-08
RA5165       26364       21083      0.53870E-02
VA5165       26363       26364 AC   0.00000E+00
LA5165       20945       26363      0.12767E-08
RA5166       26366       21086      0.53870E-02
VA5166       26365       26366 AC   0.00000E+00
LA5166       20948       26365      0.12767E-08
RA5167       26368       21089      0.53870E-02
VA5167       26367       26368 AC   0.00000E+00
LA5167       20951       26367      0.12767E-08
RA5168       26370       21092      0.53870E-02
VA5168       26369       26370 AC   0.00000E+00
LA5168       20954       26369      0.12767E-08
RA5169       26372       21095      0.53870E-02
VA5169       26371       26372 AC   0.00000E+00
LA5169       20957       26371      0.12767E-08
RA5170       26374       21098      0.53870E-02
VA5170       26373       26374 AC   0.00000E+00
LA5170       20960       26373      0.12767E-08
RA5171       26376       21101      0.53870E-02
VA5171       26375       26376 AC   0.00000E+00
LA5171       20963       26375      0.12767E-08
RA5172       26378       21104      0.53870E-02
VA5172       26377       26378 AC   0.00000E+00
LA5172       20966       26377      0.17730E-09
RA5173       26380       21107      0.53870E-02
VA5173       26379       26380 AC   0.00000E+00
LA5173       20969       26379      0.12767E-08
RA5174       26382       21110      0.53870E-02
VA5174       26381       26382 AC   0.00000E+00
LA5174       20972       26381      0.12767E-08
RA5175       26384       21113      0.53870E-02
VA5175       26383       26384 AC   0.00000E+00
LA5175       20975       26383      0.12767E-08
RA5176       26386       21116      0.53870E-02
VA5176       26385       26386 AC   0.00000E+00
LA5176       20978       26385      0.12767E-08
RA5177       26388       21119      0.53870E-02
VA5177       26387       26388 AC   0.00000E+00
LA5177       20981       26387      0.12767E-08
RA5178       26390       21122      0.53870E-02
VA5178       26389       26390 AC   0.00000E+00
LA5178       20984       26389      0.12767E-08
RA5179       26392       21125      0.53870E-02
VA5179       26391       26392 AC   0.00000E+00
LA5179       20987       26391      0.12767E-08
RA5180       26394       21128      0.53870E-02
VA5180       26393       26394 AC   0.00000E+00
LA5180       20990       26393      0.12767E-08
RA5181       26396       21131      0.53870E-02
VA5181       26395       26396 AC   0.00000E+00
LA5181       20993       26395      0.12767E-08
RA5182       26398       21134      0.53870E-02
VA5182       26397       26398 AC   0.00000E+00
LA5182       20996       26397      0.12767E-08
RA5183       26400       21137      0.53870E-02
VA5183       26399       26400 AC   0.00000E+00
LA5183       20999       26399      0.12767E-08
RA5184       26402       21140      0.53870E-02
VA5184       26401       26402 AC   0.00000E+00
LA5184       21002       26401      0.12767E-08
RA5185       26404       21143      0.53870E-02
VA5185       26403       26404 AC   0.00000E+00
LA5185       21005       26403      0.12767E-08
RA5186       26406       21146      0.53870E-02
VA5186       26405       26406 AC   0.00000E+00
LA5186       21008       26405      0.12767E-08
RA5187       26408       21149      0.53870E-02
VA5187       26407       26408 AC   0.00000E+00
LA5187       21011       26407      0.12767E-08
RA5188       26410       21152      0.53870E-02
VA5188       26409       26410 AC   0.00000E+00
LA5188       21014       26409      0.12767E-08
RA5189       26412       21155      0.53870E-02
VA5189       26411       26412 AC   0.00000E+00
LA5189       21017       26411      0.12767E-08
RA5190       26414       21158      0.53870E-02
VA5190       26413       26414 AC   0.00000E+00
LA5190       21020       26413      0.12767E-08
RA5191       26416       21161      0.53870E-02
VA5191       26415       26416 AC   0.00000E+00
LA5191       21023       26415      0.12767E-08
RA5192       26418       21164      0.53870E-02
VA5192       26417       26418 AC   0.00000E+00
LA5192       21026       26417      0.70074E-09
RA5193       26420       21165      0.53870E-02
VA5193       26419       26420 AC   0.00000E+00
LA5193       21065       26419      0.70437E-09
RA5194       26422       21168      0.53870E-02
VA5194       26421       26422 AC   0.00000E+00
LA5194       21068       26421      0.12767E-08
RA5195       26424       21171      0.53870E-02
VA5195       26423       26424 AC   0.00000E+00
LA5195       21071       26423      0.12767E-08
RA5196       26426       21174      0.53870E-02
VA5196       26425       26426 AC   0.00000E+00
LA5196       21074       26425      0.12767E-08
RA5197       26428       21177      0.53870E-02
VA5197       26427       26428 AC   0.00000E+00
LA5197       21077       26427      0.12767E-08
RA5198       26430       21180      0.53870E-02
VA5198       26429       26430 AC   0.00000E+00
LA5198       21080       26429      0.12767E-08
RA5199       26432       21183      0.53870E-02
VA5199       26431       26432 AC   0.00000E+00
LA5199       21083       26431      0.12767E-08
RA5200       26434       21186      0.53870E-02
VA5200       26433       26434 AC   0.00000E+00
LA5200       21086       26433      0.12767E-08
RA5201       26436       21189      0.53870E-02
VA5201       26435       26436 AC   0.00000E+00
LA5201       21089       26435      0.12767E-08
RA5202       26438       21192      0.53870E-02
VA5202       26437       26438 AC   0.00000E+00
LA5202       21092       26437      0.12767E-08
RA5203       26440       21195      0.53870E-02
VA5203       26439       26440 AC   0.00000E+00
LA5203       21095       26439      0.12767E-08
RA5204       26442       21198      0.53870E-02
VA5204       26441       26442 AC   0.00000E+00
LA5204       21098       26441      0.12767E-08
RA5205       26444       21201      0.53870E-02
VA5205       26443       26444 AC   0.00000E+00
LA5205       21101       26443      0.12767E-08
RA5206       26446       21204      0.53870E-02
VA5206       26445       26446 AC   0.00000E+00
LA5206       21104       26445      0.19652E-09
RA5207       26448       21207      0.53870E-02
VA5207       26447       26448 AC   0.00000E+00
LA5207       21107       26447      0.12767E-08
RA5208       26450       21210      0.53870E-02
VA5208       26449       26450 AC   0.00000E+00
LA5208       21110       26449      0.12767E-08
RA5209       26452       21213      0.53870E-02
VA5209       26451       26452 AC   0.00000E+00
LA5209       21113       26451      0.12767E-08
RA5210       26454       21216      0.53870E-02
VA5210       26453       26454 AC   0.00000E+00
LA5210       21116       26453      0.12767E-08
RA5211       26456       21219      0.53870E-02
VA5211       26455       26456 AC   0.00000E+00
LA5211       21119       26455      0.12767E-08
RA5212       26458       21222      0.53870E-02
VA5212       26457       26458 AC   0.00000E+00
LA5212       21122       26457      0.12767E-08
RA5213       26460       21225      0.53870E-02
VA5213       26459       26460 AC   0.00000E+00
LA5213       21125       26459      0.12767E-08
RA5214       26462       21228      0.53870E-02
VA5214       26461       26462 AC   0.00000E+00
LA5214       21128       26461      0.12767E-08
RA5215       26464       21231      0.53870E-02
VA5215       26463       26464 AC   0.00000E+00
LA5215       21131       26463      0.12767E-08
RA5216       26466       21234      0.53870E-02
VA5216       26465       26466 AC   0.00000E+00
LA5216       21134       26465      0.12767E-08
RA5217       26468       21237      0.53870E-02
VA5217       26467       26468 AC   0.00000E+00
LA5217       21137       26467      0.12767E-08
RA5218       26470       21240      0.53870E-02
VA5218       26469       26470 AC   0.00000E+00
LA5218       21140       26469      0.12767E-08
RA5219       26472       21243      0.53870E-02
VA5219       26471       26472 AC   0.00000E+00
LA5219       21143       26471      0.12767E-08
RA5220       26474       21246      0.53870E-02
VA5220       26473       26474 AC   0.00000E+00
LA5220       21146       26473      0.12767E-08
RA5221       26476       21249      0.53870E-02
VA5221       26475       26476 AC   0.00000E+00
LA5221       21149       26475      0.12767E-08
RA5222       26478       21252      0.53870E-02
VA5222       26477       26478 AC   0.00000E+00
LA5222       21152       26477      0.12767E-08
RA5223       26480       21255      0.53870E-02
VA5223       26479       26480 AC   0.00000E+00
LA5223       21155       26479      0.12767E-08
RA5224       26482       21258      0.53870E-02
VA5224       26481       26482 AC   0.00000E+00
LA5224       21158       26481      0.12767E-08
RA5225       26484       21261      0.53870E-02
VA5225       26483       26484 AC   0.00000E+00
LA5225       21161       26483      0.12767E-08
RA5226       26486       21264      0.53870E-02
VA5226       26485       26486 AC   0.00000E+00
LA5226       21164       26485      0.12477E-09
RA5227       26488       21265      0.53870E-02
VA5227       26487       26488 AC   0.00000E+00
LA5227       21165       26487      0.13203E-09
RA5228       26490       21268      0.53870E-02
VA5228       26489       26490 AC   0.00000E+00
LA5228       21168       26489      0.12767E-08
RA5229       26492       21271      0.53870E-02
VA5229       26491       26492 AC   0.00000E+00
LA5229       21171       26491      0.12767E-08
RA5230       26494       21274      0.53870E-02
VA5230       26493       26494 AC   0.00000E+00
LA5230       21174       26493      0.12767E-08
RA5231       26496       21277      0.53870E-02
VA5231       26495       26496 AC   0.00000E+00
LA5231       21177       26495      0.12767E-08
RA5232       26498       21280      0.53870E-02
VA5232       26497       26498 AC   0.00000E+00
LA5232       21180       26497      0.12767E-08
RA5233       26500       21283      0.53870E-02
VA5233       26499       26500 AC   0.00000E+00
LA5233       21183       26499      0.12767E-08
RA5234       26502       21286      0.53870E-02
VA5234       26501       26502 AC   0.00000E+00
LA5234       21186       26501      0.12767E-08
RA5235       26504       21289      0.53870E-02
VA5235       26503       26504 AC   0.00000E+00
LA5235       21189       26503      0.12767E-08
RA5236       26506       21292      0.53870E-02
VA5236       26505       26506 AC   0.00000E+00
LA5236       21192       26505      0.12767E-08
RA5237       26508       21295      0.53870E-02
VA5237       26507       26508 AC   0.00000E+00
LA5237       21195       26507      0.12767E-08
RA5238       26510       21298      0.53870E-02
VA5238       26509       26510 AC   0.00000E+00
LA5238       21198       26509      0.12767E-08
RA5239       26512       21301      0.53870E-02
VA5239       26511       26512 AC   0.00000E+00
LA5239       21201       26511      0.12767E-08
RA5240       26514       21304      0.53870E-02
VA5240       26513       26514 AC   0.00000E+00
LA5240       21204       26513      0.21575E-09
RA5241       26516       21307      0.53870E-02
VA5241       26515       26516 AC   0.00000E+00
LA5241       21207       26515      0.12767E-08
RA5242       26518       21310      0.53870E-02
VA5242       26517       26518 AC   0.00000E+00
LA5242       21210       26517      0.12767E-08
RA5243       26520       21313      0.53870E-02
VA5243       26519       26520 AC   0.00000E+00
LA5243       21213       26519      0.12767E-08
RA5244       26522       21316      0.53870E-02
VA5244       26521       26522 AC   0.00000E+00
LA5244       21216       26521      0.12767E-08
RA5245       26524       21319      0.53870E-02
VA5245       26523       26524 AC   0.00000E+00
LA5245       21219       26523      0.12767E-08
RA5246       26526       21322      0.53870E-02
VA5246       26525       26526 AC   0.00000E+00
LA5246       21222       26525      0.12767E-08
RA5247       26528       21325      0.53870E-02
VA5247       26527       26528 AC   0.00000E+00
LA5247       21225       26527      0.12767E-08
RA5248       26530       21328      0.53870E-02
VA5248       26529       26530 AC   0.00000E+00
LA5248       21228       26529      0.12767E-08
RA5249       26532       21331      0.53870E-02
VA5249       26531       26532 AC   0.00000E+00
LA5249       21231       26531      0.12767E-08
RA5250       26534       21334      0.53870E-02
VA5250       26533       26534 AC   0.00000E+00
LA5250       21234       26533      0.12767E-08
RA5251       26536       21337      0.53870E-02
VA5251       26535       26536 AC   0.00000E+00
LA5251       21237       26535      0.12767E-08
RA5252       26538       21340      0.53870E-02
VA5252       26537       26538 AC   0.00000E+00
LA5252       21240       26537      0.12767E-08
RA5253       26540       21343      0.53870E-02
VA5253       26539       26540 AC   0.00000E+00
LA5253       21243       26539      0.12767E-08
RA5254       26542       21346      0.53870E-02
VA5254       26541       26542 AC   0.00000E+00
LA5254       21246       26541      0.12767E-08
RA5255       26544       21349      0.53870E-02
VA5255       26543       26544 AC   0.00000E+00
LA5255       21249       26543      0.12767E-08
RA5256       26546       21352      0.53870E-02
VA5256       26545       26546 AC   0.00000E+00
LA5256       21252       26545      0.12767E-08
RA5257       26548       21355      0.53870E-02
VA5257       26547       26548 AC   0.00000E+00
LA5257       21255       26547      0.12767E-08
RA5258       26550       21358      0.53870E-02
VA5258       26549       26550 AC   0.00000E+00
LA5258       21258       26549      0.12767E-08
RA5259       26552       21361      0.53870E-02
VA5259       26551       26552 AC   0.00000E+00
LA5259       21261       26551      0.12767E-08
RA5260       26554       21364      0.53870E-02
VA5260       26553       26554 AC   0.00000E+00
LA5260       21264       26553      0.12477E-09
RA5261       26556       21365      0.53870E-02
VA5261       26555       26556 AC   0.00000E+00
LA5261       21265       26555      0.13203E-09
RA5262       26558       21368      0.53870E-02
VA5262       26557       26558 AC   0.00000E+00
LA5262       21268       26557      0.12767E-08
RA5263       26560       21371      0.53870E-02
VA5263       26559       26560 AC   0.00000E+00
LA5263       21271       26559      0.12767E-08
RA5264       26562       21374      0.53870E-02
VA5264       26561       26562 AC   0.00000E+00
LA5264       21274       26561      0.12767E-08
RA5265       26564       21377      0.53870E-02
VA5265       26563       26564 AC   0.00000E+00
LA5265       21277       26563      0.12767E-08
RA5266       26566       21380      0.53870E-02
VA5266       26565       26566 AC   0.00000E+00
LA5266       21280       26565      0.12767E-08
RA5267       26568       21383      0.53870E-02
VA5267       26567       26568 AC   0.00000E+00
LA5267       21283       26567      0.12767E-08
RA5268       26570       21386      0.53870E-02
VA5268       26569       26570 AC   0.00000E+00
LA5268       21286       26569      0.12767E-08
RA5269       26572       21389      0.53870E-02
VA5269       26571       26572 AC   0.00000E+00
LA5269       21289       26571      0.12767E-08
RA5270       26574       21392      0.53870E-02
VA5270       26573       26574 AC   0.00000E+00
LA5270       21292       26573      0.12767E-08
RA5271       26576       21395      0.53870E-02
VA5271       26575       26576 AC   0.00000E+00
LA5271       21295       26575      0.12767E-08
RA5272       26578       21398      0.53870E-02
VA5272       26577       26578 AC   0.00000E+00
LA5272       21298       26577      0.12767E-08
RA5273       26580       21401      0.53870E-02
VA5273       26579       26580 AC   0.00000E+00
LA5273       21301       26579      0.12767E-08
RA5274       26582       21404      0.53870E-02
VA5274       26581       26582 AC   0.00000E+00
LA5274       21304       26581      0.21575E-09
RA5275       26584       21407      0.53870E-02
VA5275       26583       26584 AC   0.00000E+00
LA5275       21307       26583      0.12767E-08
RA5276       26586       21410      0.53870E-02
VA5276       26585       26586 AC   0.00000E+00
LA5276       21310       26585      0.12767E-08
RA5277       26588       21413      0.53870E-02
VA5277       26587       26588 AC   0.00000E+00
LA5277       21313       26587      0.12767E-08
RA5278       26590       21416      0.53870E-02
VA5278       26589       26590 AC   0.00000E+00
LA5278       21316       26589      0.12767E-08
RA5279       26592       21419      0.53870E-02
VA5279       26591       26592 AC   0.00000E+00
LA5279       21319       26591      0.12767E-08
RA5280       26594       21422      0.53870E-02
VA5280       26593       26594 AC   0.00000E+00
LA5280       21322       26593      0.12767E-08
RA5281       26596       21425      0.53870E-02
VA5281       26595       26596 AC   0.00000E+00
LA5281       21325       26595      0.12767E-08
RA5282       26598       21428      0.53870E-02
VA5282       26597       26598 AC   0.00000E+00
LA5282       21328       26597      0.12767E-08
RA5283       26600       21431      0.53870E-02
VA5283       26599       26600 AC   0.00000E+00
LA5283       21331       26599      0.12767E-08
RA5284       26602       21434      0.53870E-02
VA5284       26601       26602 AC   0.00000E+00
LA5284       21334       26601      0.12767E-08
RA5285       26604       21437      0.53870E-02
VA5285       26603       26604 AC   0.00000E+00
LA5285       21337       26603      0.12767E-08
RA5286       26606       21440      0.53870E-02
VA5286       26605       26606 AC   0.00000E+00
LA5286       21340       26605      0.12767E-08
RA5287       26608       21443      0.53870E-02
VA5287       26607       26608 AC   0.00000E+00
LA5287       21343       26607      0.12767E-08
RA5288       26610       21446      0.53870E-02
VA5288       26609       26610 AC   0.00000E+00
LA5288       21346       26609      0.12767E-08
RA5289       26612       21449      0.53870E-02
VA5289       26611       26612 AC   0.00000E+00
LA5289       21349       26611      0.12767E-08
RA5290       26614       21452      0.53870E-02
VA5290       26613       26614 AC   0.00000E+00
LA5290       21352       26613      0.12767E-08
RA5291       26616       21455      0.53870E-02
VA5291       26615       26616 AC   0.00000E+00
LA5291       21355       26615      0.12767E-08
RA5292       26618       21458      0.53870E-02
VA5292       26617       26618 AC   0.00000E+00
LA5292       21358       26617      0.12767E-08
RA5293       26620       21461      0.53870E-02
VA5293       26619       26620 AC   0.00000E+00
LA5293       21361       26619      0.12767E-08
RA5294       26622       21464      0.53870E-02
VA5294       26621       26622 AC   0.00000E+00
LA5294       21364       26621      0.12477E-09
RA5295       26624       21465      0.53870E-02
VA5295       26623       26624 AC   0.00000E+00
LA5295       21365       26623      0.13203E-09
RA5296       26626       21468      0.53870E-02
VA5296       26625       26626 AC   0.00000E+00
LA5296       21368       26625      0.12767E-08
RA5297       26628       21471      0.53870E-02
VA5297       26627       26628 AC   0.00000E+00
LA5297       21371       26627      0.12767E-08
RA5298       26630       21474      0.53870E-02
VA5298       26629       26630 AC   0.00000E+00
LA5298       21374       26629      0.12767E-08
RA5299       26632       21477      0.53870E-02
VA5299       26631       26632 AC   0.00000E+00
LA5299       21377       26631      0.12767E-08
RA5300       26634       21480      0.53870E-02
VA5300       26633       26634 AC   0.00000E+00
LA5300       21380       26633      0.12767E-08
RA5301       26636       21483      0.53870E-02
VA5301       26635       26636 AC   0.00000E+00
LA5301       21383       26635      0.12767E-08
RA5302       26638       21486      0.53870E-02
VA5302       26637       26638 AC   0.00000E+00
LA5302       21386       26637      0.12767E-08
RA5303       26640       21489      0.53870E-02
VA5303       26639       26640 AC   0.00000E+00
LA5303       21389       26639      0.12767E-08
RA5304       26642       21492      0.53870E-02
VA5304       26641       26642 AC   0.00000E+00
LA5304       21392       26641      0.12767E-08
RA5305       26644       21495      0.53870E-02
VA5305       26643       26644 AC   0.00000E+00
LA5305       21395       26643      0.12767E-08
RA5306       26646       21498      0.53870E-02
VA5306       26645       26646 AC   0.00000E+00
LA5306       21398       26645      0.12767E-08
RA5307       26648       21501      0.53870E-02
VA5307       26647       26648 AC   0.00000E+00
LA5307       21401       26647      0.12767E-08
RA5308       26650       21504      0.53870E-02
VA5308       26649       26650 AC   0.00000E+00
LA5308       21404       26649      0.21575E-09
RA5309       26652       21507      0.53870E-02
VA5309       26651       26652 AC   0.00000E+00
LA5309       21407       26651      0.12767E-08
RA5310       26654       21510      0.53870E-02
VA5310       26653       26654 AC   0.00000E+00
LA5310       21410       26653      0.12767E-08
RA5311       26656       21513      0.53870E-02
VA5311       26655       26656 AC   0.00000E+00
LA5311       21413       26655      0.12767E-08
RA5312       26658       21516      0.53870E-02
VA5312       26657       26658 AC   0.00000E+00
LA5312       21416       26657      0.12767E-08
RA5313       26660       21519      0.53870E-02
VA5313       26659       26660 AC   0.00000E+00
LA5313       21419       26659      0.12767E-08
RA5314       26662       21522      0.53870E-02
VA5314       26661       26662 AC   0.00000E+00
LA5314       21422       26661      0.12767E-08
RA5315       26664       21525      0.53870E-02
VA5315       26663       26664 AC   0.00000E+00
LA5315       21425       26663      0.12767E-08
RA5316       26666       21528      0.53870E-02
VA5316       26665       26666 AC   0.00000E+00
LA5316       21428       26665      0.12767E-08
RA5317       26668       21531      0.53870E-02
VA5317       26667       26668 AC   0.00000E+00
LA5317       21431       26667      0.12767E-08
RA5318       26670       21534      0.53870E-02
VA5318       26669       26670 AC   0.00000E+00
LA5318       21434       26669      0.12767E-08
RA5319       26672       21537      0.53870E-02
VA5319       26671       26672 AC   0.00000E+00
LA5319       21437       26671      0.12767E-08
RA5320       26674       21540      0.53870E-02
VA5320       26673       26674 AC   0.00000E+00
LA5320       21440       26673      0.12767E-08
RA5321       26676       21543      0.53870E-02
VA5321       26675       26676 AC   0.00000E+00
LA5321       21443       26675      0.12767E-08
RA5322       26678       21546      0.53870E-02
VA5322       26677       26678 AC   0.00000E+00
LA5322       21446       26677      0.12767E-08
RA5323       26680       21549      0.53870E-02
VA5323       26679       26680 AC   0.00000E+00
LA5323       21449       26679      0.12767E-08
RA5324       26682       21552      0.53870E-02
VA5324       26681       26682 AC   0.00000E+00
LA5324       21452       26681      0.12767E-08
RA5325       26684       21555      0.53870E-02
VA5325       26683       26684 AC   0.00000E+00
LA5325       21455       26683      0.12767E-08
RA5326       26686       21558      0.53870E-02
VA5326       26685       26686 AC   0.00000E+00
LA5326       21458       26685      0.12767E-08
RA5327       26688       21561      0.53870E-02
VA5327       26687       26688 AC   0.00000E+00
LA5327       21461       26687      0.12767E-08
RA5328       26690       21564      0.53870E-02
VA5328       26689       26690 AC   0.00000E+00
LA5328       21464       26689      0.12477E-09
RA5329       26692       21565      0.53870E-02
VA5329       26691       26692 AC   0.00000E+00
LA5329       21465       26691      0.13203E-09
RA5330       26694       21568      0.53870E-02
VA5330       26693       26694 AC   0.00000E+00
LA5330       21468       26693      0.12767E-08
RA5331       26696       21571      0.53870E-02
VA5331       26695       26696 AC   0.00000E+00
LA5331       21471       26695      0.12767E-08
RA5332       26698       21574      0.53870E-02
VA5332       26697       26698 AC   0.00000E+00
LA5332       21474       26697      0.12767E-08
RA5333       26700       21577      0.53870E-02
VA5333       26699       26700 AC   0.00000E+00
LA5333       21477       26699      0.12767E-08
RA5334       26702       21580      0.53870E-02
VA5334       26701       26702 AC   0.00000E+00
LA5334       21480       26701      0.12767E-08
RA5335       26704       21583      0.53870E-02
VA5335       26703       26704 AC   0.00000E+00
LA5335       21483       26703      0.12767E-08
RA5336       26706       21586      0.53870E-02
VA5336       26705       26706 AC   0.00000E+00
LA5336       21486       26705      0.12767E-08
RA5337       26708       21589      0.53870E-02
VA5337       26707       26708 AC   0.00000E+00
LA5337       21489       26707      0.12767E-08
RA5338       26710       21592      0.53870E-02
VA5338       26709       26710 AC   0.00000E+00
LA5338       21492       26709      0.12767E-08
RA5339       26712       21595      0.53870E-02
VA5339       26711       26712 AC   0.00000E+00
LA5339       21495       26711      0.12767E-08
RA5340       26714       21598      0.53870E-02
VA5340       26713       26714 AC   0.00000E+00
LA5340       21498       26713      0.12767E-08
RA5341       26716       21601      0.53870E-02
VA5341       26715       26716 AC   0.00000E+00
LA5341       21501       26715      0.12767E-08
RA5342       26718       21604      0.53870E-02
VA5342       26717       26718 AC   0.00000E+00
LA5342       21504       26717      0.21575E-09
RA5343       26720       21607      0.53870E-02
VA5343       26719       26720 AC   0.00000E+00
LA5343       21507       26719      0.12767E-08
RA5344       26722       21610      0.53870E-02
VA5344       26721       26722 AC   0.00000E+00
LA5344       21510       26721      0.12767E-08
RA5345       26724       21613      0.53870E-02
VA5345       26723       26724 AC   0.00000E+00
LA5345       21513       26723      0.12767E-08
RA5346       26726       21616      0.53870E-02
VA5346       26725       26726 AC   0.00000E+00
LA5346       21516       26725      0.12767E-08
RA5347       26728       21619      0.53870E-02
VA5347       26727       26728 AC   0.00000E+00
LA5347       21519       26727      0.12767E-08
RA5348       26730       21622      0.53870E-02
VA5348       26729       26730 AC   0.00000E+00
LA5348       21522       26729      0.12767E-08
RA5349       26732       21625      0.53870E-02
VA5349       26731       26732 AC   0.00000E+00
LA5349       21525       26731      0.12767E-08
RA5350       26734       21628      0.53870E-02
VA5350       26733       26734 AC   0.00000E+00
LA5350       21528       26733      0.12767E-08
RA5351       26736       21631      0.53870E-02
VA5351       26735       26736 AC   0.00000E+00
LA5351       21531       26735      0.12767E-08
RA5352       26738       21634      0.53870E-02
VA5352       26737       26738 AC   0.00000E+00
LA5352       21534       26737      0.12767E-08
RA5353       26740       21637      0.53870E-02
VA5353       26739       26740 AC   0.00000E+00
LA5353       21537       26739      0.12767E-08
RA5354       26742       21640      0.53870E-02
VA5354       26741       26742 AC   0.00000E+00
LA5354       21540       26741      0.12767E-08
RA5355       26744       21643      0.53870E-02
VA5355       26743       26744 AC   0.00000E+00
LA5355       21543       26743      0.12767E-08
RA5356       26746       21646      0.53870E-02
VA5356       26745       26746 AC   0.00000E+00
LA5356       21546       26745      0.12767E-08
RA5357       26748       21649      0.53870E-02
VA5357       26747       26748 AC   0.00000E+00
LA5357       21549       26747      0.12767E-08
RA5358       26750       21652      0.53870E-02
VA5358       26749       26750 AC   0.00000E+00
LA5358       21552       26749      0.12767E-08
RA5359       26752       21655      0.53870E-02
VA5359       26751       26752 AC   0.00000E+00
LA5359       21555       26751      0.12767E-08
RA5360       26754       21658      0.53870E-02
VA5360       26753       26754 AC   0.00000E+00
LA5360       21558       26753      0.12767E-08
RA5361       26756       21661      0.53870E-02
VA5361       26755       26756 AC   0.00000E+00
LA5361       21561       26755      0.12767E-08
RA5362       26758       21664      0.53870E-02
VA5362       26757       26758 AC   0.00000E+00
LA5362       21564       26757      0.12477E-09
RA5363       26760       21665      0.53870E-02
VA5363       26759       26760 AC   0.00000E+00
LA5363       21565       26759      0.13203E-09
RA5364       26762       21668      0.53870E-02
VA5364       26761       26762 AC   0.00000E+00
LA5364       21568       26761      0.12767E-08
RA5365       26764       21671      0.53870E-02
VA5365       26763       26764 AC   0.00000E+00
LA5365       21571       26763      0.12767E-08
RA5366       26766       21674      0.53870E-02
VA5366       26765       26766 AC   0.00000E+00
LA5366       21574       26765      0.12767E-08
RA5367       26768       21677      0.53870E-02
VA5367       26767       26768 AC   0.00000E+00
LA5367       21577       26767      0.12767E-08
RA5368       26770       21680      0.53870E-02
VA5368       26769       26770 AC   0.00000E+00
LA5368       21580       26769      0.12767E-08
RA5369       26772       21683      0.53870E-02
VA5369       26771       26772 AC   0.00000E+00
LA5369       21583       26771      0.12767E-08
RA5370       26774       21686      0.53870E-02
VA5370       26773       26774 AC   0.00000E+00
LA5370       21586       26773      0.12767E-08
RA5371       26776       21689      0.53870E-02
VA5371       26775       26776 AC   0.00000E+00
LA5371       21589       26775      0.12767E-08
RA5372       26778       21692      0.53870E-02
VA5372       26777       26778 AC   0.00000E+00
LA5372       21592       26777      0.12767E-08
RA5373       26780       21695      0.53870E-02
VA5373       26779       26780 AC   0.00000E+00
LA5373       21595       26779      0.12767E-08
RA5374       26782       21698      0.53870E-02
VA5374       26781       26782 AC   0.00000E+00
LA5374       21598       26781      0.12767E-08
RA5375       26784       21701      0.53870E-02
VA5375       26783       26784 AC   0.00000E+00
LA5375       21601       26783      0.12767E-08
RA5376       26786       21704      0.53870E-02
VA5376       26785       26786 AC   0.00000E+00
LA5376       21604       26785      0.21575E-09
RA5377       26788       21707      0.53870E-02
VA5377       26787       26788 AC   0.00000E+00
LA5377       21607       26787      0.12767E-08
RA5378       26790       21710      0.53870E-02
VA5378       26789       26790 AC   0.00000E+00
LA5378       21610       26789      0.12767E-08
RA5379       26792       21713      0.53870E-02
VA5379       26791       26792 AC   0.00000E+00
LA5379       21613       26791      0.12767E-08
RA5380       26794       21716      0.53870E-02
VA5380       26793       26794 AC   0.00000E+00
LA5380       21616       26793      0.12767E-08
RA5381       26796       21719      0.53870E-02
VA5381       26795       26796 AC   0.00000E+00
LA5381       21619       26795      0.12767E-08
RA5382       26798       21722      0.53870E-02
VA5382       26797       26798 AC   0.00000E+00
LA5382       21622       26797      0.12767E-08
RA5383       26800       21725      0.53870E-02
VA5383       26799       26800 AC   0.00000E+00
LA5383       21625       26799      0.12767E-08
RA5384       26802       21728      0.53870E-02
VA5384       26801       26802 AC   0.00000E+00
LA5384       21628       26801      0.12767E-08
RA5385       26804       21731      0.53870E-02
VA5385       26803       26804 AC   0.00000E+00
LA5385       21631       26803      0.12767E-08
RA5386       26806       21734      0.53870E-02
VA5386       26805       26806 AC   0.00000E+00
LA5386       21634       26805      0.12767E-08
RA5387       26808       21737      0.53870E-02
VA5387       26807       26808 AC   0.00000E+00
LA5387       21637       26807      0.12767E-08
RA5388       26810       21740      0.53870E-02
VA5388       26809       26810 AC   0.00000E+00
LA5388       21640       26809      0.12767E-08
RA5389       26812       21743      0.53870E-02
VA5389       26811       26812 AC   0.00000E+00
LA5389       21643       26811      0.12767E-08
RA5390       26814       21746      0.53870E-02
VA5390       26813       26814 AC   0.00000E+00
LA5390       21646       26813      0.12767E-08
RA5391       26816       21749      0.53870E-02
VA5391       26815       26816 AC   0.00000E+00
LA5391       21649       26815      0.12767E-08
RA5392       26818       21752      0.53870E-02
VA5392       26817       26818 AC   0.00000E+00
LA5392       21652       26817      0.12767E-08
RA5393       26820       21755      0.53870E-02
VA5393       26819       26820 AC   0.00000E+00
LA5393       21655       26819      0.12767E-08
RA5394       26822       21758      0.53870E-02
VA5394       26821       26822 AC   0.00000E+00
LA5394       21658       26821      0.12767E-08
RA5395       26824       21761      0.53870E-02
VA5395       26823       26824 AC   0.00000E+00
LA5395       21661       26823      0.12767E-08
RA5396       26826       21764      0.53870E-02
VA5396       26825       26826 AC   0.00000E+00
LA5396       21664       26825      0.12477E-09
RA5397       26828       21765      0.53870E-02
VA5397       26827       26828 AC   0.00000E+00
LA5397       21665       26827      0.13203E-09
RA5398       26830       21768      0.53870E-02
VA5398       26829       26830 AC   0.00000E+00
LA5398       21668       26829      0.12767E-08
RA5399       26832       21771      0.53870E-02
VA5399       26831       26832 AC   0.00000E+00
LA5399       21671       26831      0.12767E-08
RA5400       26834       21774      0.53870E-02
VA5400       26833       26834 AC   0.00000E+00
LA5400       21674       26833      0.12767E-08
RA5401       26836       21777      0.53870E-02
VA5401       26835       26836 AC   0.00000E+00
LA5401       21677       26835      0.12767E-08
RA5402       26838       21780      0.53870E-02
VA5402       26837       26838 AC   0.00000E+00
LA5402       21680       26837      0.12767E-08
RA5403       26840       21783      0.53870E-02
VA5403       26839       26840 AC   0.00000E+00
LA5403       21683       26839      0.12767E-08
RA5404       26842       21786      0.53870E-02
VA5404       26841       26842 AC   0.00000E+00
LA5404       21686       26841      0.12767E-08
RA5405       26844       21789      0.53870E-02
VA5405       26843       26844 AC   0.00000E+00
LA5405       21689       26843      0.12767E-08
RA5406       26846       21792      0.53870E-02
VA5406       26845       26846 AC   0.00000E+00
LA5406       21692       26845      0.12767E-08
RA5407       26848       21795      0.53870E-02
VA5407       26847       26848 AC   0.00000E+00
LA5407       21695       26847      0.12767E-08
RA5408       26850       21798      0.53870E-02
VA5408       26849       26850 AC   0.00000E+00
LA5408       21698       26849      0.12767E-08
RA5409       26852       21801      0.53870E-02
VA5409       26851       26852 AC   0.00000E+00
LA5409       21701       26851      0.12767E-08
RA5410       26854       21804      0.53870E-02
VA5410       26853       26854 AC   0.00000E+00
LA5410       21704       26853      0.21575E-09
RA5411       26856       21807      0.53870E-02
VA5411       26855       26856 AC   0.00000E+00
LA5411       21707       26855      0.12767E-08
RA5412       26858       21810      0.53870E-02
VA5412       26857       26858 AC   0.00000E+00
LA5412       21710       26857      0.12767E-08
RA5413       26860       21813      0.53870E-02
VA5413       26859       26860 AC   0.00000E+00
LA5413       21713       26859      0.12767E-08
RA5414       26862       21816      0.53870E-02
VA5414       26861       26862 AC   0.00000E+00
LA5414       21716       26861      0.12767E-08
RA5415       26864       21819      0.53870E-02
VA5415       26863       26864 AC   0.00000E+00
LA5415       21719       26863      0.12767E-08
RA5416       26866       21822      0.53870E-02
VA5416       26865       26866 AC   0.00000E+00
LA5416       21722       26865      0.12767E-08
RA5417       26868       21825      0.53870E-02
VA5417       26867       26868 AC   0.00000E+00
LA5417       21725       26867      0.12767E-08
RA5418       26870       21828      0.53870E-02
VA5418       26869       26870 AC   0.00000E+00
LA5418       21728       26869      0.12767E-08
RA5419       26872       21831      0.53870E-02
VA5419       26871       26872 AC   0.00000E+00
LA5419       21731       26871      0.12767E-08
RA5420       26874       21834      0.53870E-02
VA5420       26873       26874 AC   0.00000E+00
LA5420       21734       26873      0.12767E-08
RA5421       26876       21837      0.53870E-02
VA5421       26875       26876 AC   0.00000E+00
LA5421       21737       26875      0.12767E-08
RA5422       26878       21840      0.53870E-02
VA5422       26877       26878 AC   0.00000E+00
LA5422       21740       26877      0.12767E-08
RA5423       26880       21843      0.53870E-02
VA5423       26879       26880 AC   0.00000E+00
LA5423       21743       26879      0.12767E-08
RA5424       26882       21846      0.53870E-02
VA5424       26881       26882 AC   0.00000E+00
LA5424       21746       26881      0.12767E-08
RA5425       26884       21849      0.53870E-02
VA5425       26883       26884 AC   0.00000E+00
LA5425       21749       26883      0.12767E-08
RA5426       26886       21852      0.53870E-02
VA5426       26885       26886 AC   0.00000E+00
LA5426       21752       26885      0.12767E-08
RA5427       26888       21855      0.53870E-02
VA5427       26887       26888 AC   0.00000E+00
LA5427       21755       26887      0.12767E-08
RA5428       26890       21858      0.53870E-02
VA5428       26889       26890 AC   0.00000E+00
LA5428       21758       26889      0.12767E-08
RA5429       26892       21861      0.53870E-02
VA5429       26891       26892 AC   0.00000E+00
LA5429       21761       26891      0.12767E-08
RA5430       26894       21864      0.53870E-02
VA5430       26893       26894 AC   0.00000E+00
LA5430       21764       26893      0.12477E-09
RA5431       26896       21865      0.53870E-02
VA5431       26895       26896 AC   0.00000E+00
LA5431       21765       26895      0.13203E-09
RA5432       26898       21868      0.53870E-02
VA5432       26897       26898 AC   0.00000E+00
LA5432       21768       26897      0.12767E-08
RA5433       26900       21871      0.53870E-02
VA5433       26899       26900 AC   0.00000E+00
LA5433       21771       26899      0.12767E-08
RA5434       26902       21874      0.53870E-02
VA5434       26901       26902 AC   0.00000E+00
LA5434       21774       26901      0.12767E-08
RA5435       26904       21877      0.53870E-02
VA5435       26903       26904 AC   0.00000E+00
LA5435       21777       26903      0.12767E-08
RA5436       26906       21880      0.53870E-02
VA5436       26905       26906 AC   0.00000E+00
LA5436       21780       26905      0.12767E-08
RA5437       26908       21883      0.53870E-02
VA5437       26907       26908 AC   0.00000E+00
LA5437       21783       26907      0.12767E-08
RA5438       26910       21886      0.53870E-02
VA5438       26909       26910 AC   0.00000E+00
LA5438       21786       26909      0.12767E-08
RA5439       26912       21889      0.53870E-02
VA5439       26911       26912 AC   0.00000E+00
LA5439       21789       26911      0.12767E-08
RA5440       26914       21892      0.53870E-02
VA5440       26913       26914 AC   0.00000E+00
LA5440       21792       26913      0.12767E-08
RA5441       26916       21895      0.53870E-02
VA5441       26915       26916 AC   0.00000E+00
LA5441       21795       26915      0.12767E-08
RA5442       26918       21898      0.53870E-02
VA5442       26917       26918 AC   0.00000E+00
LA5442       21798       26917      0.12767E-08
RA5443       26920       21901      0.53870E-02
VA5443       26919       26920 AC   0.00000E+00
LA5443       21801       26919      0.12767E-08
RA5444       26922       21904      0.53870E-02
VA5444       26921       26922 AC   0.00000E+00
LA5444       21804       26921      0.21575E-09
RA5445       26924       21907      0.53870E-02
VA5445       26923       26924 AC   0.00000E+00
LA5445       21807       26923      0.12767E-08
RA5446       26926       21910      0.53870E-02
VA5446       26925       26926 AC   0.00000E+00
LA5446       21810       26925      0.12767E-08
RA5447       26928       21913      0.53870E-02
VA5447       26927       26928 AC   0.00000E+00
LA5447       21813       26927      0.12767E-08
RA5448       26930       21916      0.53870E-02
VA5448       26929       26930 AC   0.00000E+00
LA5448       21816       26929      0.12767E-08
RA5449       26932       21919      0.53870E-02
VA5449       26931       26932 AC   0.00000E+00
LA5449       21819       26931      0.12767E-08
RA5450       26934       21922      0.53870E-02
VA5450       26933       26934 AC   0.00000E+00
LA5450       21822       26933      0.12767E-08
RA5451       26936       21925      0.53870E-02
VA5451       26935       26936 AC   0.00000E+00
LA5451       21825       26935      0.12767E-08
RA5452       26938       21928      0.53870E-02
VA5452       26937       26938 AC   0.00000E+00
LA5452       21828       26937      0.12767E-08
RA5453       26940       21931      0.53870E-02
VA5453       26939       26940 AC   0.00000E+00
LA5453       21831       26939      0.12767E-08
RA5454       26942       21934      0.53870E-02
VA5454       26941       26942 AC   0.00000E+00
LA5454       21834       26941      0.12767E-08
RA5455       26944       21937      0.53870E-02
VA5455       26943       26944 AC   0.00000E+00
LA5455       21837       26943      0.12767E-08
RA5456       26946       21940      0.53870E-02
VA5456       26945       26946 AC   0.00000E+00
LA5456       21840       26945      0.12767E-08
RA5457       26948       21943      0.53870E-02
VA5457       26947       26948 AC   0.00000E+00
LA5457       21843       26947      0.12767E-08
RA5458       26950       21946      0.53870E-02
VA5458       26949       26950 AC   0.00000E+00
LA5458       21846       26949      0.12767E-08
RA5459       26952       21949      0.53870E-02
VA5459       26951       26952 AC   0.00000E+00
LA5459       21849       26951      0.12767E-08
RA5460       26954       21952      0.53870E-02
VA5460       26953       26954 AC   0.00000E+00
LA5460       21852       26953      0.12767E-08
RA5461       26956       21955      0.53870E-02
VA5461       26955       26956 AC   0.00000E+00
LA5461       21855       26955      0.12767E-08
RA5462       26958       21958      0.53870E-02
VA5462       26957       26958 AC   0.00000E+00
LA5462       21858       26957      0.12767E-08
RA5463       26960       21961      0.53870E-02
VA5463       26959       26960 AC   0.00000E+00
LA5463       21861       26959      0.12767E-08
RA5464       26962       21964      0.53870E-02
VA5464       26961       26962 AC   0.00000E+00
LA5464       21864       26961      0.12477E-09
RA5465       26964       21967      0.53870E-02
VA5465       26963       26964 AC   0.00000E+00
LA5465       21907       26963      0.12767E-08
RA5466       26966       21970      0.53870E-02
VA5466       26965       26966 AC   0.00000E+00
LA5466       21910       26965      0.12767E-08
RA5467       26968       21973      0.53870E-02
VA5467       26967       26968 AC   0.00000E+00
LA5467       21913       26967      0.12767E-08
RA5468       26970       21976      0.53870E-02
VA5468       26969       26970 AC   0.00000E+00
LA5468       21916       26969      0.12767E-08
RA5469       26972       21979      0.53870E-02
VA5469       26971       26972 AC   0.00000E+00
LA5469       21919       26971      0.12767E-08
RA5470       26974       21982      0.53870E-02
VA5470       26973       26974 AC   0.00000E+00
LA5470       21922       26973      0.12767E-08
RA5471       26976       21985      0.53870E-02
VA5471       26975       26976 AC   0.00000E+00
LA5471       21925       26975      0.12767E-08
RA5472       26978       21988      0.53870E-02
VA5472       26977       26978 AC   0.00000E+00
LA5472       21928       26977      0.12767E-08
RA5473       26980       21991      0.53870E-02
VA5473       26979       26980 AC   0.00000E+00
LA5473       21931       26979      0.12767E-08
RA5474       26982       21994      0.53870E-02
VA5474       26981       26982 AC   0.00000E+00
LA5474       21934       26981      0.12767E-08
RA5475       26984       21997      0.53870E-02
VA5475       26983       26984 AC   0.00000E+00
LA5475       21937       26983      0.12767E-08
RA5476       26986       22000      0.53870E-02
VA5476       26985       26986 AC   0.00000E+00
LA5476       21940       26985      0.12767E-08
RA5477       26988       22003      0.53870E-02
VA5477       26987       26988 AC   0.00000E+00
LA5477       21943       26987      0.12767E-08
RA5478       26990       22006      0.53870E-02
VA5478       26989       26990 AC   0.00000E+00
LA5478       21946       26989      0.12767E-08
RA5479       26992       22009      0.53870E-02
VA5479       26991       26992 AC   0.00000E+00
LA5479       21949       26991      0.12767E-08
RA5480       26994       22012      0.53870E-02
VA5480       26993       26994 AC   0.00000E+00
LA5480       21952       26993      0.12767E-08
RA5481       26996       22015      0.53870E-02
VA5481       26995       26996 AC   0.00000E+00
LA5481       21955       26995      0.12767E-08
RA5482       26998       22018      0.53870E-02
VA5482       26997       26998 AC   0.00000E+00
LA5482       21958       26997      0.12767E-08
RA5483       27000       22021      0.53870E-02
VA5483       26999       27000 AC   0.00000E+00
LA5483       21961       26999      0.12767E-08
RA5484       27002       22024      0.53870E-02
VA5484       27001       27002 AC   0.00000E+00
LA5484       21964       27001      0.12477E-09
RA5485       27004       22025      0.53870E-02
VA5485       27003       27004 AC   0.00000E+00
LA5485       21994       27003      0.70672E-09
RA5486       27006       22028      0.53870E-02
VA5486       27005       27006 AC   0.00000E+00
LA5486       21997       27005      0.12767E-08
RA5487       27008       22031      0.53870E-02
VA5487       27007       27008 AC   0.00000E+00
LA5487       22000       27007      0.12767E-08
RA5488       27010       22034      0.53870E-02
VA5488       27009       27010 AC   0.00000E+00
LA5488       22003       27009      0.12767E-08
RA5489       27012       22037      0.53870E-02
VA5489       27011       27012 AC   0.00000E+00
LA5489       22006       27011      0.12767E-08
RA5490       27014       22040      0.53870E-02
VA5490       27013       27014 AC   0.00000E+00
LA5490       22009       27013      0.12767E-08
RA5491       27016       22043      0.53870E-02
VA5491       27015       27016 AC   0.00000E+00
LA5491       22012       27015      0.12767E-08
RA5492       27018       22046      0.53870E-02
VA5492       27017       27018 AC   0.00000E+00
LA5492       22015       27017      0.12767E-08
RA5493       27020       22049      0.53870E-02
VA5493       27019       27020 AC   0.00000E+00
LA5493       22018       27019      0.12767E-08
RA5494       27022       22052      0.53870E-02
VA5494       27021       27022 AC   0.00000E+00
LA5494       22021       27021      0.12767E-08
RA5495       27024       22055      0.53870E-02
VA5495       27023       27024 AC   0.00000E+00
LA5495       22024       27023      0.13076E-09
RA5496       27026       22056      0.53870E-02
VA5496       27025       27026 AC   0.00000E+00
LA5496       22025       27025      0.13674E-09
RA5497       27028       22059      0.53870E-02
VA5497       27027       27028 AC   0.00000E+00
LA5497       22028       27027      0.12767E-08
RA5498       27030       22062      0.53870E-02
VA5498       27029       27030 AC   0.00000E+00
LA5498       22031       27029      0.12767E-08
RA5499       27032       22065      0.53870E-02
VA5499       27031       27032 AC   0.00000E+00
LA5499       22034       27031      0.12767E-08
RA5500       27034       22068      0.53870E-02
VA5500       27033       27034 AC   0.00000E+00
LA5500       22037       27033      0.12767E-08
RA5501       27036       22071      0.53870E-02
VA5501       27035       27036 AC   0.00000E+00
LA5501       22040       27035      0.12767E-08
RA5502       27038       22074      0.53870E-02
VA5502       27037       27038 AC   0.00000E+00
LA5502       22043       27037      0.12767E-08
RA5503       27040       22077      0.53870E-02
VA5503       27039       27040 AC   0.00000E+00
LA5503       22046       27039      0.12767E-08
RA5504       27042       22080      0.53870E-02
VA5504       27041       27042 AC   0.00000E+00
LA5504       22049       27041      0.12767E-08
RA5505       27044       22083      0.53870E-02
VA5505       27043       27044 AC   0.00000E+00
LA5505       22052       27043      0.12767E-08
RA5506       27046       22086      0.53870E-02
VA5506       27045       27046 AC   0.00000E+00
LA5506       22055       27045      0.13674E-09
RA5507       27048       22087      0.53870E-02
VA5507       27047       27048 AC   0.00000E+00
LA5507       22056       27047      0.13674E-09
RA5508       27050       22090      0.53870E-02
VA5508       27049       27050 AC   0.00000E+00
LA5508       22059       27049      0.12767E-08
RA5509       27052       22093      0.53870E-02
VA5509       27051       27052 AC   0.00000E+00
LA5509       22062       27051      0.12767E-08
RA5510       27054       22096      0.53870E-02
VA5510       27053       27054 AC   0.00000E+00
LA5510       22065       27053      0.12767E-08
RA5511       27056       22099      0.53870E-02
VA5511       27055       27056 AC   0.00000E+00
LA5511       22068       27055      0.12767E-08
RA5512       27058       22102      0.53870E-02
VA5512       27057       27058 AC   0.00000E+00
LA5512       22071       27057      0.12767E-08
RA5513       27060       22105      0.53870E-02
VA5513       27059       27060 AC   0.00000E+00
LA5513       22074       27059      0.12767E-08
RA5514       27062       22108      0.53870E-02
VA5514       27061       27062 AC   0.00000E+00
LA5514       22077       27061      0.12767E-08
RA5515       27064       22111      0.53870E-02
VA5515       27063       27064 AC   0.00000E+00
LA5515       22080       27063      0.12767E-08
RA5516       27066       22114      0.53870E-02
VA5516       27065       27066 AC   0.00000E+00
LA5516       22083       27065      0.12767E-08
RA5517       27068       22117      0.53870E-02
VA5517       27067       27068 AC   0.00000E+00
LA5517       22086       27067      0.13674E-09
RA5518       27070       22137      0.53870E-02
VA5518       27069       27070 AC   0.00000E+00
LA5518       22087       27069      0.13674E-09
RA5519       27072       22140      0.53870E-02
VA5519       27071       27072 AC   0.00000E+00
LA5519       22090       27071      0.12767E-08
RA5520       27074       22143      0.53870E-02
VA5520       27073       27074 AC   0.00000E+00
LA5520       22093       27073      0.12767E-08
RA5521       27076       22146      0.53870E-02
VA5521       27075       27076 AC   0.00000E+00
LA5521       22096       27075      0.12767E-08
RA5522       27078       22149      0.53870E-02
VA5522       27077       27078 AC   0.00000E+00
LA5522       22099       27077      0.12767E-08
RA5523       27080       22152      0.53870E-02
VA5523       27079       27080 AC   0.00000E+00
LA5523       22102       27079      0.12767E-08
RA5524       27082       22155      0.53870E-02
VA5524       27081       27082 AC   0.00000E+00
LA5524       22105       27081      0.12767E-08
RA5525       27084       22158      0.53870E-02
VA5525       27083       27084 AC   0.00000E+00
LA5525       22108       27083      0.12767E-08
RA5526       27086       22161      0.53870E-02
VA5526       27085       27086 AC   0.00000E+00
LA5526       22111       27085      0.12767E-08
RA5527       27088       22164      0.53870E-02
VA5527       27087       27088 AC   0.00000E+00
LA5527       22114       27087      0.12767E-08
RA5528       27090       22167      0.53870E-02
VA5528       27089       27090 AC   0.00000E+00
LA5528       22117       27089      0.13674E-09
RA5529       27092       22168      0.53870E-02
VA5529       27091       27092 AC   0.00000E+00
LA5529       22118       27091      0.23931E-09
RA5530       27094       22171      0.53870E-02
VA5530       27093       27094 AC   0.00000E+00
LA5530       22121       27093      0.12767E-08
RA5531       27096       22174      0.53870E-02
VA5531       27095       27096 AC   0.00000E+00
LA5531       22124       27095      0.12767E-08
RA5532       27098       22177      0.53870E-02
VA5532       27097       27098 AC   0.00000E+00
LA5532       22127       27097      0.12767E-08
RA5533       27100       22180      0.53870E-02
VA5533       27099       27100 AC   0.00000E+00
LA5533       22130       27099      0.12767E-08
RA5534       27102       22183      0.53870E-02
VA5534       27101       27102 AC   0.00000E+00
LA5534       22133       27101      0.12767E-08
RA5535       27104       22186      0.53870E-02
VA5535       27103       27104 AC   0.00000E+00
LA5535       22136       27103      0.14613E-09
RA5536       27106       22187      0.53870E-02
VA5536       27105       27106 AC   0.00000E+00
LA5536       22137       27105      0.13674E-09
RA5537       27108       22190      0.53870E-02
VA5537       27107       27108 AC   0.00000E+00
LA5537       22140       27107      0.12767E-08
RA5538       27110       22193      0.53870E-02
VA5538       27109       27110 AC   0.00000E+00
LA5538       22143       27109      0.12767E-08
RA5539       27112       22196      0.53870E-02
VA5539       27111       27112 AC   0.00000E+00
LA5539       22146       27111      0.12767E-08
RA5540       27114       22199      0.53870E-02
VA5540       27113       27114 AC   0.00000E+00
LA5540       22149       27113      0.12767E-08
RA5541       27116       22202      0.53870E-02
VA5541       27115       27116 AC   0.00000E+00
LA5541       22152       27115      0.12767E-08
RA5542       27118       22205      0.53870E-02
VA5542       27117       27118 AC   0.00000E+00
LA5542       22155       27117      0.12767E-08
RA5543       27120       22208      0.53870E-02
VA5543       27119       27120 AC   0.00000E+00
LA5543       22158       27119      0.12767E-08
RA5544       27122       22211      0.53870E-02
VA5544       27121       27122 AC   0.00000E+00
LA5544       22161       27121      0.12767E-08
RA5545       27124       22214      0.53870E-02
VA5545       27123       27124 AC   0.00000E+00
LA5545       22164       27123      0.12767E-08
RA5546       27126       22217      0.53870E-02
VA5546       27125       27126 AC   0.00000E+00
LA5546       22167       27125      0.13674E-09
RA5547       27128       22218      0.53870E-02
VA5547       27127       27128 AC   0.00000E+00
LA5547       22168       27127      0.23931E-09
RA5548       27130       22221      0.53870E-02
VA5548       27129       27130 AC   0.00000E+00
LA5548       22171       27129      0.12767E-08
RA5549       27132       22224      0.53870E-02
VA5549       27131       27132 AC   0.00000E+00
LA5549       22174       27131      0.12767E-08
RA5550       27134       22227      0.53870E-02
VA5550       27133       27134 AC   0.00000E+00
LA5550       22177       27133      0.12767E-08
RA5551       27136       22230      0.53870E-02
VA5551       27135       27136 AC   0.00000E+00
LA5551       22180       27135      0.12767E-08
RA5552       27138       22233      0.53870E-02
VA5552       27137       27138 AC   0.00000E+00
LA5552       22183       27137      0.12767E-08
RA5553       27140       22236      0.53870E-02
VA5553       27139       27140 AC   0.00000E+00
LA5553       22186       27139      0.14613E-09
RA5554       27142       22237      0.53870E-02
VA5554       27141       27142 AC   0.00000E+00
LA5554       22187       27141      0.13674E-09
RA5555       27144       22240      0.53870E-02
VA5555       27143       27144 AC   0.00000E+00
LA5555       22190       27143      0.12767E-08
RA5556       27146       22243      0.53870E-02
VA5556       27145       27146 AC   0.00000E+00
LA5556       22193       27145      0.12767E-08
RA5557       27148       22246      0.53870E-02
VA5557       27147       27148 AC   0.00000E+00
LA5557       22196       27147      0.12767E-08
RA5558       27150       22249      0.53870E-02
VA5558       27149       27150 AC   0.00000E+00
LA5558       22199       27149      0.12767E-08
RA5559       27152       22252      0.53870E-02
VA5559       27151       27152 AC   0.00000E+00
LA5559       22202       27151      0.12767E-08
RA5560       27154       22255      0.53870E-02
VA5560       27153       27154 AC   0.00000E+00
LA5560       22205       27153      0.12767E-08
RA5561       27156       22258      0.53870E-02
VA5561       27155       27156 AC   0.00000E+00
LA5561       22208       27155      0.12767E-08
RA5562       27158       22261      0.53870E-02
VA5562       27157       27158 AC   0.00000E+00
LA5562       22211       27157      0.12767E-08
RA5563       27160       22264      0.53870E-02
VA5563       27159       27160 AC   0.00000E+00
LA5563       22214       27159      0.12767E-08
RA5564       27162       22267      0.53870E-02
VA5564       27161       27162 AC   0.00000E+00
LA5564       22217       27161      0.13674E-09
RA5565       27164       22268      0.53870E-02
VA5565       27163       27164 AC   0.00000E+00
LA5565       22218       27163      0.23931E-09
RA5566       27166       22271      0.53870E-02
VA5566       27165       27166 AC   0.00000E+00
LA5566       22221       27165      0.12767E-08
RA5567       27168       22274      0.53870E-02
VA5567       27167       27168 AC   0.00000E+00
LA5567       22224       27167      0.12767E-08
RA5568       27170       22277      0.53870E-02
VA5568       27169       27170 AC   0.00000E+00
LA5568       22227       27169      0.12767E-08
RA5569       27172       22280      0.53870E-02
VA5569       27171       27172 AC   0.00000E+00
LA5569       22230       27171      0.12767E-08
RA5570       27174       22283      0.53870E-02
VA5570       27173       27174 AC   0.00000E+00
LA5570       22233       27173      0.12767E-08
RA5571       27176       22286      0.53870E-02
VA5571       27175       27176 AC   0.00000E+00
LA5571       22236       27175      0.14613E-09
RA5572       27178       22287      0.53870E-02
VA5572       27177       27178 AC   0.00000E+00
LA5572       22237       27177      0.13674E-09
RA5573       27180       22290      0.53870E-02
VA5573       27179       27180 AC   0.00000E+00
LA5573       22240       27179      0.12767E-08
RA5574       27182       22293      0.53870E-02
VA5574       27181       27182 AC   0.00000E+00
LA5574       22243       27181      0.12767E-08
RA5575       27184       22296      0.53870E-02
VA5575       27183       27184 AC   0.00000E+00
LA5575       22246       27183      0.12767E-08
RA5576       27186       22299      0.53870E-02
VA5576       27185       27186 AC   0.00000E+00
LA5576       22249       27185      0.12767E-08
RA5577       27188       22302      0.53870E-02
VA5577       27187       27188 AC   0.00000E+00
LA5577       22252       27187      0.12767E-08
RA5578       27190       22305      0.53870E-02
VA5578       27189       27190 AC   0.00000E+00
LA5578       22255       27189      0.12767E-08
RA5579       27192       22308      0.53870E-02
VA5579       27191       27192 AC   0.00000E+00
LA5579       22258       27191      0.12767E-08
RA5580       27194       22311      0.53870E-02
VA5580       27193       27194 AC   0.00000E+00
LA5580       22261       27193      0.12767E-08
RA5581       27196       22314      0.53870E-02
VA5581       27195       27196 AC   0.00000E+00
LA5581       22264       27195      0.12767E-08
RA5582       27198       22317      0.53870E-02
VA5582       27197       27198 AC   0.00000E+00
LA5582       22267       27197      0.13674E-09
RA5583       27200       22318      0.53870E-02
VA5583       27199       27200 AC   0.00000E+00
LA5583       22268       27199      0.23931E-09
RA5584       27202       22321      0.53870E-02
VA5584       27201       27202 AC   0.00000E+00
LA5584       22271       27201      0.12767E-08
RA5585       27204       22324      0.53870E-02
VA5585       27203       27204 AC   0.00000E+00
LA5585       22274       27203      0.12767E-08
RA5586       27206       22327      0.53870E-02
VA5586       27205       27206 AC   0.00000E+00
LA5586       22277       27205      0.12767E-08
RA5587       27208       22330      0.53870E-02
VA5587       27207       27208 AC   0.00000E+00
LA5587       22280       27207      0.12767E-08
RA5588       27210       22333      0.53870E-02
VA5588       27209       27210 AC   0.00000E+00
LA5588       22283       27209      0.12767E-08
RA5589       27212       22336      0.53870E-02
VA5589       27211       27212 AC   0.00000E+00
LA5589       22286       27211      0.14613E-09
RA5590       27214       22337      0.53870E-02
VA5590       27213       27214 AC   0.00000E+00
LA5590       22287       27213      0.13674E-09
RA5591       27216       22340      0.53870E-02
VA5591       27215       27216 AC   0.00000E+00
LA5591       22290       27215      0.12767E-08
RA5592       27218       22343      0.53870E-02
VA5592       27217       27218 AC   0.00000E+00
LA5592       22293       27217      0.12767E-08
RA5593       27220       22346      0.53870E-02
VA5593       27219       27220 AC   0.00000E+00
LA5593       22296       27219      0.12767E-08
RA5594       27222       22349      0.53870E-02
VA5594       27221       27222 AC   0.00000E+00
LA5594       22299       27221      0.12767E-08
RA5595       27224       22352      0.53870E-02
VA5595       27223       27224 AC   0.00000E+00
LA5595       22302       27223      0.12767E-08
RA5596       27226       22355      0.53870E-02
VA5596       27225       27226 AC   0.00000E+00
LA5596       22305       27225      0.12767E-08
RA5597       27228       22358      0.53870E-02
VA5597       27227       27228 AC   0.00000E+00
LA5597       22308       27227      0.12767E-08
RA5598       27230       22361      0.53870E-02
VA5598       27229       27230 AC   0.00000E+00
LA5598       22311       27229      0.12767E-08
RA5599       27232       22364      0.53870E-02
VA5599       27231       27232 AC   0.00000E+00
LA5599       22314       27231      0.12767E-08
RA5600       27234       22367      0.53870E-02
VA5600       27233       27234 AC   0.00000E+00
LA5600       22317       27233      0.13674E-09
RA5601       27236       22368      0.53870E-02
VA5601       27235       27236 AC   0.00000E+00
LA5601       22318       27235      0.23931E-09
RA5602       27238       22371      0.53870E-02
VA5602       27237       27238 AC   0.00000E+00
LA5602       22321       27237      0.12767E-08
RA5603       27240       22374      0.53870E-02
VA5603       27239       27240 AC   0.00000E+00
LA5603       22324       27239      0.12767E-08
RA5604       27242       22377      0.53870E-02
VA5604       27241       27242 AC   0.00000E+00
LA5604       22327       27241      0.12767E-08
RA5605       27244       22380      0.53870E-02
VA5605       27243       27244 AC   0.00000E+00
LA5605       22330       27243      0.12767E-08
RA5606       27246       22383      0.53870E-02
VA5606       27245       27246 AC   0.00000E+00
LA5606       22333       27245      0.12767E-08
RA5607       27248       22386      0.53870E-02
VA5607       27247       27248 AC   0.00000E+00
LA5607       22336       27247      0.14613E-09
RA5608       27250       22387      0.53870E-02
VA5608       27249       27250 AC   0.00000E+00
LA5608       22337       27249      0.13674E-09
RA5609       27252       22390      0.53870E-02
VA5609       27251       27252 AC   0.00000E+00
LA5609       22340       27251      0.12767E-08
RA5610       27254       22393      0.53870E-02
VA5610       27253       27254 AC   0.00000E+00
LA5610       22343       27253      0.12767E-08
RA5611       27256       22396      0.53870E-02
VA5611       27255       27256 AC   0.00000E+00
LA5611       22346       27255      0.12767E-08
RA5612       27258       22399      0.53870E-02
VA5612       27257       27258 AC   0.00000E+00
LA5612       22349       27257      0.12767E-08
RA5613       27260       22402      0.53870E-02
VA5613       27259       27260 AC   0.00000E+00
LA5613       22352       27259      0.12767E-08
RA5614       27262       22405      0.53870E-02
VA5614       27261       27262 AC   0.00000E+00
LA5614       22355       27261      0.12767E-08
RA5615       27264       22408      0.53870E-02
VA5615       27263       27264 AC   0.00000E+00
LA5615       22358       27263      0.12767E-08
RA5616       27266       22411      0.53870E-02
VA5616       27265       27266 AC   0.00000E+00
LA5616       22361       27265      0.12767E-08
RA5617       27268       22414      0.53870E-02
VA5617       27267       27268 AC   0.00000E+00
LA5617       22364       27267      0.12767E-08
RA5618       27270       22417      0.53870E-02
VA5618       27269       27270 AC   0.00000E+00
LA5618       22367       27269      0.13674E-09
RA5619       27272       22418      0.53870E-02
VA5619       27271       27272 AC   0.00000E+00
LA5619       22368       27271      0.23931E-09
RA5620       27274       22421      0.53870E-02
VA5620       27273       27274 AC   0.00000E+00
LA5620       22371       27273      0.12767E-08
RA5621       27276       22424      0.53870E-02
VA5621       27275       27276 AC   0.00000E+00
LA5621       22374       27275      0.12767E-08
RA5622       27278       22427      0.53870E-02
VA5622       27277       27278 AC   0.00000E+00
LA5622       22377       27277      0.12767E-08
RA5623       27280       22430      0.53870E-02
VA5623       27279       27280 AC   0.00000E+00
LA5623       22380       27279      0.12767E-08
RA5624       27282       22433      0.53870E-02
VA5624       27281       27282 AC   0.00000E+00
LA5624       22383       27281      0.12767E-08
RA5625       27284       22436      0.53870E-02
VA5625       27283       27284 AC   0.00000E+00
LA5625       22386       27283      0.14613E-09
RA5626       27286       22437      0.53870E-02
VA5626       27285       27286 AC   0.00000E+00
LA5626       22387       27285      0.13674E-09
RA5627       27288       22440      0.53870E-02
VA5627       27287       27288 AC   0.00000E+00
LA5627       22390       27287      0.12767E-08
RA5628       27290       22443      0.53870E-02
VA5628       27289       27290 AC   0.00000E+00
LA5628       22393       27289      0.12767E-08
RA5629       27292       22446      0.53870E-02
VA5629       27291       27292 AC   0.00000E+00
LA5629       22396       27291      0.12767E-08
RA5630       27294       22449      0.53870E-02
VA5630       27293       27294 AC   0.00000E+00
LA5630       22399       27293      0.12767E-08
RA5631       27296       22452      0.53870E-02
VA5631       27295       27296 AC   0.00000E+00
LA5631       22402       27295      0.12767E-08
RA5632       27298       22455      0.53870E-02
VA5632       27297       27298 AC   0.00000E+00
LA5632       22405       27297      0.12767E-08
RA5633       27300       22458      0.53870E-02
VA5633       27299       27300 AC   0.00000E+00
LA5633       22408       27299      0.12767E-08
RA5634       27302       22461      0.53870E-02
VA5634       27301       27302 AC   0.00000E+00
LA5634       22411       27301      0.12767E-08
RA5635       27304       22464      0.53870E-02
VA5635       27303       27304 AC   0.00000E+00
LA5635       22414       27303      0.12767E-08
RA5636       27306       22467      0.53870E-02
VA5636       27305       27306 AC   0.00000E+00
LA5636       22417       27305      0.13674E-09
RA5637       27308       22468      0.53870E-02
VA5637       27307       27308 AC   0.00000E+00
LA5637       22418       27307      0.23931E-09
RA5638       27310       22471      0.53870E-02
VA5638       27309       27310 AC   0.00000E+00
LA5638       22421       27309      0.12767E-08
RA5639       27312       22474      0.53870E-02
VA5639       27311       27312 AC   0.00000E+00
LA5639       22424       27311      0.12767E-08
RA5640       27314       22477      0.53870E-02
VA5640       27313       27314 AC   0.00000E+00
LA5640       22427       27313      0.12767E-08
RA5641       27316       22480      0.53870E-02
VA5641       27315       27316 AC   0.00000E+00
LA5641       22430       27315      0.12767E-08
RA5642       27318       22483      0.53870E-02
VA5642       27317       27318 AC   0.00000E+00
LA5642       22433       27317      0.12767E-08
RA5643       27320       22486      0.53870E-02
VA5643       27319       27320 AC   0.00000E+00
LA5643       22436       27319      0.14613E-09
RA5644       27322       22487      0.53870E-02
VA5644       27321       27322 AC   0.00000E+00
LA5644       22437       27321      0.13674E-09
RA5645       27324       22490      0.53870E-02
VA5645       27323       27324 AC   0.00000E+00
LA5645       22440       27323      0.12767E-08
RA5646       27326       22493      0.53870E-02
VA5646       27325       27326 AC   0.00000E+00
LA5646       22443       27325      0.12767E-08
RA5647       27328       22496      0.53870E-02
VA5647       27327       27328 AC   0.00000E+00
LA5647       22446       27327      0.12767E-08
RA5648       27330       22499      0.53870E-02
VA5648       27329       27330 AC   0.00000E+00
LA5648       22449       27329      0.12767E-08
RA5649       27332       22502      0.53870E-02
VA5649       27331       27332 AC   0.00000E+00
LA5649       22452       27331      0.12767E-08
RA5650       27334       22505      0.53870E-02
VA5650       27333       27334 AC   0.00000E+00
LA5650       22455       27333      0.12767E-08
RA5651       27336       22508      0.53870E-02
VA5651       27335       27336 AC   0.00000E+00
LA5651       22458       27335      0.12767E-08
RA5652       27338       22511      0.53870E-02
VA5652       27337       27338 AC   0.00000E+00
LA5652       22461       27337      0.12767E-08
RA5653       27340       22514      0.53870E-02
VA5653       27339       27340 AC   0.00000E+00
LA5653       22464       27339      0.12767E-08
RA5654       27342       22517      0.53870E-02
VA5654       27341       27342 AC   0.00000E+00
LA5654       22467       27341      0.13674E-09
RA5655       27344       22518      0.53870E-02
VA5655       27343       27344 AC   0.00000E+00
LA5655       22468       27343      0.23931E-09
RA5656       27346       22521      0.53870E-02
VA5656       27345       27346 AC   0.00000E+00
LA5656       22471       27345      0.12767E-08
RA5657       27348       22524      0.53870E-02
VA5657       27347       27348 AC   0.00000E+00
LA5657       22474       27347      0.12767E-08
RA5658       27350       22527      0.53870E-02
VA5658       27349       27350 AC   0.00000E+00
LA5658       22477       27349      0.12767E-08
RA5659       27352       22530      0.53870E-02
VA5659       27351       27352 AC   0.00000E+00
LA5659       22480       27351      0.12767E-08
RA5660       27354       22533      0.53870E-02
VA5660       27353       27354 AC   0.00000E+00
LA5660       22483       27353      0.12767E-08
RA5661       27356       22536      0.53870E-02
VA5661       27355       27356 AC   0.00000E+00
LA5661       22486       27355      0.14613E-09
RA5662       27358       22537      0.53870E-02
VA5662       27357       27358 AC   0.00000E+00
LA5662       22487       27357      0.13674E-09
RA5663       27360       22540      0.53870E-02
VA5663       27359       27360 AC   0.00000E+00
LA5663       22490       27359      0.12767E-08
RA5664       27362       22543      0.53870E-02
VA5664       27361       27362 AC   0.00000E+00
LA5664       22493       27361      0.12767E-08
RA5665       27364       22546      0.53870E-02
VA5665       27363       27364 AC   0.00000E+00
LA5665       22496       27363      0.12767E-08
RA5666       27366       22549      0.53870E-02
VA5666       27365       27366 AC   0.00000E+00
LA5666       22499       27365      0.12767E-08
RA5667       27368       22552      0.53870E-02
VA5667       27367       27368 AC   0.00000E+00
LA5667       22502       27367      0.12767E-08
RA5668       27370       22555      0.53870E-02
VA5668       27369       27370 AC   0.00000E+00
LA5668       22505       27369      0.12767E-08
RA5669       27372       22558      0.53870E-02
VA5669       27371       27372 AC   0.00000E+00
LA5669       22508       27371      0.12767E-08
RA5670       27374       22561      0.53870E-02
VA5670       27373       27374 AC   0.00000E+00
LA5670       22511       27373      0.12767E-08
RA5671       27376       22564      0.53870E-02
VA5671       27375       27376 AC   0.00000E+00
LA5671       22514       27375      0.12767E-08
RA5672       27378       22567      0.53870E-02
VA5672       27377       27378 AC   0.00000E+00
LA5672       22517       27377      0.13674E-09
RA5673       27380       22568      0.53870E-02
VA5673       27379       27380 AC   0.00000E+00
LA5673       22518       27379      0.23931E-09
RA5674       27382       22571      0.53870E-02
VA5674       27381       27382 AC   0.00000E+00
LA5674       22521       27381      0.12767E-08
RA5675       27384       22574      0.53870E-02
VA5675       27383       27384 AC   0.00000E+00
LA5675       22524       27383      0.12767E-08
RA5676       27386       22577      0.53870E-02
VA5676       27385       27386 AC   0.00000E+00
LA5676       22527       27385      0.12767E-08
RA5677       27388       22580      0.53870E-02
VA5677       27387       27388 AC   0.00000E+00
LA5677       22530       27387      0.12767E-08
RA5678       27390       22583      0.53870E-02
VA5678       27389       27390 AC   0.00000E+00
LA5678       22533       27389      0.12767E-08
RA5679       27392       22586      0.53870E-02
VA5679       27391       27392 AC   0.00000E+00
LA5679       22536       27391      0.14613E-09
RA5680       27394       22587      0.53870E-02
VA5680       27393       27394 AC   0.00000E+00
LA5680       22537       27393      0.13674E-09
RA5681       27396       22590      0.53870E-02
VA5681       27395       27396 AC   0.00000E+00
LA5681       22540       27395      0.12767E-08
RA5682       27398       22593      0.53870E-02
VA5682       27397       27398 AC   0.00000E+00
LA5682       22543       27397      0.12767E-08
RA5683       27400       22596      0.53870E-02
VA5683       27399       27400 AC   0.00000E+00
LA5683       22546       27399      0.12767E-08
RA5684       27402       22599      0.53870E-02
VA5684       27401       27402 AC   0.00000E+00
LA5684       22549       27401      0.12767E-08
RA5685       27404       22602      0.53870E-02
VA5685       27403       27404 AC   0.00000E+00
LA5685       22552       27403      0.12767E-08
RA5686       27406       22605      0.53870E-02
VA5686       27405       27406 AC   0.00000E+00
LA5686       22555       27405      0.12767E-08
RA5687       27408       22608      0.53870E-02
VA5687       27407       27408 AC   0.00000E+00
LA5687       22558       27407      0.12767E-08
RA5688       27410       22611      0.53870E-02
VA5688       27409       27410 AC   0.00000E+00
LA5688       22561       27409      0.12767E-08
RA5689       27412       22614      0.53870E-02
VA5689       27411       27412 AC   0.00000E+00
LA5689       22564       27411      0.12767E-08
RA5690       27414       22617      0.53870E-02
VA5690       27413       27414 AC   0.00000E+00
LA5690       22567       27413      0.13674E-09
RA5691       27416       22618      0.53870E-02
VA5691       27415       27416 AC   0.00000E+00
LA5691       22568       27415      0.23931E-09
RA5692       27418       22621      0.53870E-02
VA5692       27417       27418 AC   0.00000E+00
LA5692       22571       27417      0.12767E-08
RA5693       27420       22624      0.53870E-02
VA5693       27419       27420 AC   0.00000E+00
LA5693       22574       27419      0.12767E-08
RA5694       27422       22627      0.53870E-02
VA5694       27421       27422 AC   0.00000E+00
LA5694       22577       27421      0.12767E-08
RA5695       27424       22630      0.53870E-02
VA5695       27423       27424 AC   0.00000E+00
LA5695       22580       27423      0.12767E-08
RA5696       27426       22633      0.53870E-02
VA5696       27425       27426 AC   0.00000E+00
LA5696       22583       27425      0.12767E-08
RA5697       27428       22636      0.53870E-02
VA5697       27427       27428 AC   0.00000E+00
LA5697       22586       27427      0.14613E-09
RA5698       27430       22637      0.53870E-02
VA5698       27429       27430 AC   0.00000E+00
LA5698       22587       27429      0.13674E-09
RA5699       27432       22640      0.53870E-02
VA5699       27431       27432 AC   0.00000E+00
LA5699       22590       27431      0.12767E-08
RA5700       27434       22643      0.53870E-02
VA5700       27433       27434 AC   0.00000E+00
LA5700       22593       27433      0.12767E-08
RA5701       27436       22646      0.53870E-02
VA5701       27435       27436 AC   0.00000E+00
LA5701       22596       27435      0.12767E-08
RA5702       27438       22649      0.53870E-02
VA5702       27437       27438 AC   0.00000E+00
LA5702       22599       27437      0.12767E-08
RA5703       27440       22652      0.53870E-02
VA5703       27439       27440 AC   0.00000E+00
LA5703       22602       27439      0.12767E-08
RA5704       27442       22655      0.53870E-02
VA5704       27441       27442 AC   0.00000E+00
LA5704       22605       27441      0.12767E-08
RA5705       27444       22658      0.53870E-02
VA5705       27443       27444 AC   0.00000E+00
LA5705       22608       27443      0.12767E-08
RA5706       27446       22661      0.53870E-02
VA5706       27445       27446 AC   0.00000E+00
LA5706       22611       27445      0.12767E-08
RA5707       27448       22664      0.53870E-02
VA5707       27447       27448 AC   0.00000E+00
LA5707       22614       27447      0.12767E-08
RA5708       27450       22667      0.53870E-02
VA5708       27449       27450 AC   0.00000E+00
LA5708       22617       27449      0.13674E-09
RA5709       27452       22668      0.53870E-02
VA5709       27451       27452 AC   0.00000E+00
LA5709       22618       27451      0.23931E-09
RA5710       27454       22671      0.53870E-02
VA5710       27453       27454 AC   0.00000E+00
LA5710       22621       27453      0.12767E-08
RA5711       27456       22674      0.53870E-02
VA5711       27455       27456 AC   0.00000E+00
LA5711       22624       27455      0.12767E-08
RA5712       27458       22677      0.53870E-02
VA5712       27457       27458 AC   0.00000E+00
LA5712       22627       27457      0.12767E-08
RA5713       27460       22680      0.53870E-02
VA5713       27459       27460 AC   0.00000E+00
LA5713       22630       27459      0.12767E-08
RA5714       27462       22683      0.53870E-02
VA5714       27461       27462 AC   0.00000E+00
LA5714       22633       27461      0.12767E-08
RA5715       27464       22686      0.53870E-02
VA5715       27463       27464 AC   0.00000E+00
LA5715       22636       27463      0.14613E-09
RA5716       27466       22687      0.53870E-02
VA5716       27465       27466 AC   0.00000E+00
LA5716       22637       27465      0.13674E-09
RA5717       27468       22690      0.53870E-02
VA5717       27467       27468 AC   0.00000E+00
LA5717       22640       27467      0.12767E-08
RA5718       27470       22693      0.53870E-02
VA5718       27469       27470 AC   0.00000E+00
LA5718       22643       27469      0.12767E-08
RA5719       27472       22696      0.53870E-02
VA5719       27471       27472 AC   0.00000E+00
LA5719       22646       27471      0.12767E-08
RA5720       27474       22699      0.53870E-02
VA5720       27473       27474 AC   0.00000E+00
LA5720       22649       27473      0.12767E-08
RA5721       27476       22702      0.53870E-02
VA5721       27475       27476 AC   0.00000E+00
LA5721       22652       27475      0.12767E-08
RA5722       27478       22705      0.53870E-02
VA5722       27477       27478 AC   0.00000E+00
LA5722       22655       27477      0.12767E-08
RA5723       27480       22708      0.53870E-02
VA5723       27479       27480 AC   0.00000E+00
LA5723       22658       27479      0.12767E-08
RA5724       27482       22711      0.53870E-02
VA5724       27481       27482 AC   0.00000E+00
LA5724       22661       27481      0.12767E-08
RA5725       27484       22714      0.53870E-02
VA5725       27483       27484 AC   0.00000E+00
LA5725       22664       27483      0.12767E-08
RA5726       27486       22717      0.53870E-02
VA5726       27485       27486 AC   0.00000E+00
LA5726       22667       27485      0.13674E-09
RA5727       27488       22718      0.53870E-02
VA5727       27487       27488 AC   0.00000E+00
LA5727       22668       27487      0.23931E-09
RA5728       27490       22721      0.53870E-02
VA5728       27489       27490 AC   0.00000E+00
LA5728       22671       27489      0.12767E-08
RA5729       27492       22724      0.53870E-02
VA5729       27491       27492 AC   0.00000E+00
LA5729       22674       27491      0.12767E-08
RA5730       27494       22727      0.53870E-02
VA5730       27493       27494 AC   0.00000E+00
LA5730       22677       27493      0.12767E-08
RA5731       27496       22730      0.53870E-02
VA5731       27495       27496 AC   0.00000E+00
LA5731       22680       27495      0.12767E-08
RA5732       27498       22733      0.53870E-02
VA5732       27497       27498 AC   0.00000E+00
LA5732       22683       27497      0.12767E-08
RA5733       27500       22736      0.53870E-02
VA5733       27499       27500 AC   0.00000E+00
LA5733       22686       27499      0.14613E-09
RA5734       27502       22737      0.53870E-02
VA5734       27501       27502 AC   0.00000E+00
LA5734       22687       27501      0.13674E-09
RA5735       27504       22740      0.53870E-02
VA5735       27503       27504 AC   0.00000E+00
LA5735       22690       27503      0.12767E-08
RA5736       27506       22743      0.53870E-02
VA5736       27505       27506 AC   0.00000E+00
LA5736       22693       27505      0.12767E-08
RA5737       27508       22746      0.53870E-02
VA5737       27507       27508 AC   0.00000E+00
LA5737       22696       27507      0.12767E-08
RA5738       27510       22749      0.53870E-02
VA5738       27509       27510 AC   0.00000E+00
LA5738       22699       27509      0.12767E-08
RA5739       27512       22752      0.53870E-02
VA5739       27511       27512 AC   0.00000E+00
LA5739       22702       27511      0.12767E-08
RA5740       27514       22755      0.53870E-02
VA5740       27513       27514 AC   0.00000E+00
LA5740       22705       27513      0.12767E-08
RA5741       27516       22758      0.53870E-02
VA5741       27515       27516 AC   0.00000E+00
LA5741       22708       27515      0.12767E-08
RA5742       27518       22761      0.53870E-02
VA5742       27517       27518 AC   0.00000E+00
LA5742       22711       27517      0.12767E-08
RA5743       27520       22764      0.53870E-02
VA5743       27519       27520 AC   0.00000E+00
LA5743       22714       27519      0.12767E-08
RA5744       27522       22767      0.53870E-02
VA5744       27521       27522 AC   0.00000E+00
LA5744       22717       27521      0.13674E-09
RA5745       27524       22768      0.53870E-02
VA5745       27523       27524 AC   0.00000E+00
LA5745       22718       27523      0.23931E-09
RA5746       27526       22771      0.53870E-02
VA5746       27525       27526 AC   0.00000E+00
LA5746       22721       27525      0.12767E-08
RA5747       27528       22774      0.53870E-02
VA5747       27527       27528 AC   0.00000E+00
LA5747       22724       27527      0.12767E-08
RA5748       27530       22777      0.53870E-02
VA5748       27529       27530 AC   0.00000E+00
LA5748       22727       27529      0.12767E-08
RA5749       27532       22780      0.53870E-02
VA5749       27531       27532 AC   0.00000E+00
LA5749       22730       27531      0.12767E-08
RA5750       27534       22783      0.53870E-02
VA5750       27533       27534 AC   0.00000E+00
LA5750       22733       27533      0.12767E-08
RA5751       27536       22786      0.53870E-02
VA5751       27535       27536 AC   0.00000E+00
LA5751       22736       27535      0.14613E-09
RA5752       27538       22787      0.53870E-02
VA5752       27537       27538 AC   0.00000E+00
LA5752       22737       27537      0.13674E-09
RA5753       27540       22790      0.53870E-02
VA5753       27539       27540 AC   0.00000E+00
LA5753       22740       27539      0.12767E-08
RA5754       27542       22793      0.53870E-02
VA5754       27541       27542 AC   0.00000E+00
LA5754       22743       27541      0.12767E-08
RA5755       27544       22796      0.53870E-02
VA5755       27543       27544 AC   0.00000E+00
LA5755       22746       27543      0.12767E-08
RA5756       27546       22799      0.53870E-02
VA5756       27545       27546 AC   0.00000E+00
LA5756       22749       27545      0.12767E-08
RA5757       27548       22802      0.53870E-02
VA5757       27547       27548 AC   0.00000E+00
LA5757       22752       27547      0.12767E-08
RA5758       27550       22805      0.53870E-02
VA5758       27549       27550 AC   0.00000E+00
LA5758       22755       27549      0.12767E-08
RA5759       27552       22808      0.53870E-02
VA5759       27551       27552 AC   0.00000E+00
LA5759       22758       27551      0.12767E-08
RA5760       27554       22811      0.53870E-02
VA5760       27553       27554 AC   0.00000E+00
LA5760       22761       27553      0.12767E-08
RA5761       27556       22814      0.53870E-02
VA5761       27555       27556 AC   0.00000E+00
LA5761       22764       27555      0.12767E-08
RA5762       27558       22817      0.53870E-02
VA5762       27557       27558 AC   0.00000E+00
LA5762       22767       27557      0.13674E-09
RA5763       27560       22818      0.53870E-02
VA5763       27559       27560 AC   0.00000E+00
LA5763       22768       27559      0.23931E-09
RA5764       27562       22821      0.53870E-02
VA5764       27561       27562 AC   0.00000E+00
LA5764       22771       27561      0.12767E-08
RA5765       27564       22824      0.53870E-02
VA5765       27563       27564 AC   0.00000E+00
LA5765       22774       27563      0.12767E-08
RA5766       27566       22827      0.53870E-02
VA5766       27565       27566 AC   0.00000E+00
LA5766       22777       27565      0.12767E-08
RA5767       27568       22830      0.53870E-02
VA5767       27567       27568 AC   0.00000E+00
LA5767       22780       27567      0.12767E-08
RA5768       27570       22833      0.53870E-02
VA5768       27569       27570 AC   0.00000E+00
LA5768       22783       27569      0.12767E-08
RA5769       27572       22836      0.53870E-02
VA5769       27571       27572 AC   0.00000E+00
LA5769       22786       27571      0.14613E-09
RA5770       27574       22837      0.53870E-02
VA5770       27573       27574 AC   0.00000E+00
LA5770       22787       27573      0.13674E-09
RA5771       27576       22840      0.53870E-02
VA5771       27575       27576 AC   0.00000E+00
LA5771       22790       27575      0.12767E-08
RA5772       27578       22843      0.53870E-02
VA5772       27577       27578 AC   0.00000E+00
LA5772       22793       27577      0.12767E-08
RA5773       27580       22846      0.53870E-02
VA5773       27579       27580 AC   0.00000E+00
LA5773       22796       27579      0.12767E-08
RA5774       27582       22849      0.53870E-02
VA5774       27581       27582 AC   0.00000E+00
LA5774       22799       27581      0.12767E-08
RA5775       27584       22852      0.53870E-02
VA5775       27583       27584 AC   0.00000E+00
LA5775       22802       27583      0.12767E-08
RA5776       27586       22855      0.53870E-02
VA5776       27585       27586 AC   0.00000E+00
LA5776       22805       27585      0.12767E-08
RA5777       27588       22858      0.53870E-02
VA5777       27587       27588 AC   0.00000E+00
LA5777       22808       27587      0.12767E-08
RA5778       27590       22861      0.53870E-02
VA5778       27589       27590 AC   0.00000E+00
LA5778       22811       27589      0.12767E-08
RA5779       27592       22864      0.53870E-02
VA5779       27591       27592 AC   0.00000E+00
LA5779       22814       27591      0.12767E-08
RA5780       27594       22867      0.53870E-02
VA5780       27593       27594 AC   0.00000E+00
LA5780       22817       27593      0.13674E-09
RA5781       27596       22868      0.53870E-02
VA5781       27595       27596 AC   0.00000E+00
LA5781       22818       27595      0.23931E-09
RA5782       27598       22871      0.53870E-02
VA5782       27597       27598 AC   0.00000E+00
LA5782       22821       27597      0.12767E-08
RA5783       27600       22874      0.53870E-02
VA5783       27599       27600 AC   0.00000E+00
LA5783       22824       27599      0.12767E-08
RA5784       27602       22877      0.53870E-02
VA5784       27601       27602 AC   0.00000E+00
LA5784       22827       27601      0.12767E-08
RA5785       27604       22880      0.53870E-02
VA5785       27603       27604 AC   0.00000E+00
LA5785       22830       27603      0.12767E-08
RA5786       27606       22883      0.53870E-02
VA5786       27605       27606 AC   0.00000E+00
LA5786       22833       27605      0.12767E-08
RA5787       27608       22886      0.53870E-02
VA5787       27607       27608 AC   0.00000E+00
LA5787       22836       27607      0.14613E-09
RA5788       27610       22887      0.53870E-02
VA5788       27609       27610 AC   0.00000E+00
LA5788       22837       27609      0.13674E-09
RA5789       27612       22890      0.53870E-02
VA5789       27611       27612 AC   0.00000E+00
LA5789       22840       27611      0.12767E-08
RA5790       27614       22893      0.53870E-02
VA5790       27613       27614 AC   0.00000E+00
LA5790       22843       27613      0.12767E-08
RA5791       27616       22896      0.53870E-02
VA5791       27615       27616 AC   0.00000E+00
LA5791       22846       27615      0.12767E-08
RA5792       27618       22899      0.53870E-02
VA5792       27617       27618 AC   0.00000E+00
LA5792       22849       27617      0.12767E-08
RA5793       27620       22902      0.53870E-02
VA5793       27619       27620 AC   0.00000E+00
LA5793       22852       27619      0.12767E-08
RA5794       27622       22905      0.53870E-02
VA5794       27621       27622 AC   0.00000E+00
LA5794       22855       27621      0.12767E-08
RA5795       27624       22908      0.53870E-02
VA5795       27623       27624 AC   0.00000E+00
LA5795       22858       27623      0.12767E-08
RA5796       27626       22911      0.53870E-02
VA5796       27625       27626 AC   0.00000E+00
LA5796       22861       27625      0.12767E-08
RA5797       27628       22914      0.53870E-02
VA5797       27627       27628 AC   0.00000E+00
LA5797       22864       27627      0.12767E-08
RA5798       27630       22917      0.53870E-02
VA5798       27629       27630 AC   0.00000E+00
LA5798       22867       27629      0.13674E-09
RA5799       27632       22918      0.53870E-02
VA5799       27631       27632 AC   0.00000E+00
LA5799       22868       27631      0.23931E-09
RA5800       27634       22921      0.53870E-02
VA5800       27633       27634 AC   0.00000E+00
LA5800       22871       27633      0.12767E-08
RA5801       27636       22924      0.53870E-02
VA5801       27635       27636 AC   0.00000E+00
LA5801       22874       27635      0.12767E-08
RA5802       27638       22927      0.53870E-02
VA5802       27637       27638 AC   0.00000E+00
LA5802       22877       27637      0.12767E-08
RA5803       27640       22930      0.53870E-02
VA5803       27639       27640 AC   0.00000E+00
LA5803       22880       27639      0.12767E-08
RA5804       27642       22933      0.53870E-02
VA5804       27641       27642 AC   0.00000E+00
LA5804       22883       27641      0.12767E-08
RA5805       27644       22936      0.53870E-02
VA5805       27643       27644 AC   0.00000E+00
LA5805       22886       27643      0.14613E-09
RA5806       27646       22937      0.53870E-02
VA5806       27645       27646 AC   0.00000E+00
LA5806       22887       27645      0.13674E-09
RA5807       27648       22940      0.53870E-02
VA5807       27647       27648 AC   0.00000E+00
LA5807       22890       27647      0.12767E-08
RA5808       27650       22943      0.53870E-02
VA5808       27649       27650 AC   0.00000E+00
LA5808       22893       27649      0.12767E-08
RA5809       27652       22946      0.53870E-02
VA5809       27651       27652 AC   0.00000E+00
LA5809       22896       27651      0.12767E-08
RA5810       27654       22949      0.53870E-02
VA5810       27653       27654 AC   0.00000E+00
LA5810       22899       27653      0.12767E-08
RA5811       27656       22952      0.53870E-02
VA5811       27655       27656 AC   0.00000E+00
LA5811       22902       27655      0.12767E-08
RA5812       27658       22955      0.53870E-02
VA5812       27657       27658 AC   0.00000E+00
LA5812       22905       27657      0.12767E-08
RA5813       27660       22958      0.53870E-02
VA5813       27659       27660 AC   0.00000E+00
LA5813       22908       27659      0.12767E-08
RA5814       27662       22961      0.53870E-02
VA5814       27661       27662 AC   0.00000E+00
LA5814       22911       27661      0.12767E-08
RA5815       27664       22964      0.53870E-02
VA5815       27663       27664 AC   0.00000E+00
LA5815       22914       27663      0.12767E-08
RA5816       27666       22967      0.53870E-02
VA5816       27665       27666 AC   0.00000E+00
LA5816       22917       27665      0.13674E-09
RA5817       27668       22968      0.53870E-02
VA5817       27667       27668 AC   0.00000E+00
LA5817       22918       27667      0.23931E-09
RA5818       27670       22971      0.53870E-02
VA5818       27669       27670 AC   0.00000E+00
LA5818       22921       27669      0.12767E-08
RA5819       27672       22974      0.53870E-02
VA5819       27671       27672 AC   0.00000E+00
LA5819       22924       27671      0.12767E-08
RA5820       27674       22977      0.53870E-02
VA5820       27673       27674 AC   0.00000E+00
LA5820       22927       27673      0.12767E-08
RA5821       27676       22980      0.53870E-02
VA5821       27675       27676 AC   0.00000E+00
LA5821       22930       27675      0.12767E-08
RA5822       27678       22983      0.53870E-02
VA5822       27677       27678 AC   0.00000E+00
LA5822       22933       27677      0.12767E-08
RA5823       27680       22986      0.53870E-02
VA5823       27679       27680 AC   0.00000E+00
LA5823       22936       27679      0.14613E-09
RA5824       27682       22987      0.53870E-02
VA5824       27681       27682 AC   0.00000E+00
LA5824       22937       27681      0.13674E-09
RA5825       27684       22990      0.53870E-02
VA5825       27683       27684 AC   0.00000E+00
LA5825       22940       27683      0.12767E-08
RA5826       27686       22993      0.53870E-02
VA5826       27685       27686 AC   0.00000E+00
LA5826       22943       27685      0.12767E-08
RA5827       27688       22996      0.53870E-02
VA5827       27687       27688 AC   0.00000E+00
LA5827       22946       27687      0.12767E-08
RA5828       27690       22999      0.53870E-02
VA5828       27689       27690 AC   0.00000E+00
LA5828       22949       27689      0.12767E-08
RA5829       27692       23002      0.53870E-02
VA5829       27691       27692 AC   0.00000E+00
LA5829       22952       27691      0.12767E-08
RA5830       27694       23005      0.53870E-02
VA5830       27693       27694 AC   0.00000E+00
LA5830       22955       27693      0.12767E-08
RA5831       27696       23008      0.53870E-02
VA5831       27695       27696 AC   0.00000E+00
LA5831       22958       27695      0.12767E-08
RA5832       27698       23011      0.53870E-02
VA5832       27697       27698 AC   0.00000E+00
LA5832       22961       27697      0.12767E-08
RA5833       27700       23014      0.53870E-02
VA5833       27699       27700 AC   0.00000E+00
LA5833       22964       27699      0.12767E-08
RA5834       27702       23017      0.53870E-02
VA5834       27701       27702 AC   0.00000E+00
LA5834       22967       27701      0.13674E-09
RA5835       27704       23018      0.53870E-02
VA5835       27703       27704 AC   0.00000E+00
LA5835       22968       27703      0.23931E-09
RA5836       27706       23021      0.53870E-02
VA5836       27705       27706 AC   0.00000E+00
LA5836       22971       27705      0.12767E-08
RA5837       27708       23024      0.53870E-02
VA5837       27707       27708 AC   0.00000E+00
LA5837       22974       27707      0.12767E-08
RA5838       27710       23027      0.53870E-02
VA5838       27709       27710 AC   0.00000E+00
LA5838       22977       27709      0.12767E-08
RA5839       27712       23030      0.53870E-02
VA5839       27711       27712 AC   0.00000E+00
LA5839       22980       27711      0.12767E-08
RA5840       27714       23033      0.53870E-02
VA5840       27713       27714 AC   0.00000E+00
LA5840       22983       27713      0.12767E-08
RA5841       27716       23036      0.53870E-02
VA5841       27715       27716 AC   0.00000E+00
LA5841       22986       27715      0.14613E-09
RA5842       27718       23037      0.53870E-02
VA5842       27717       27718 AC   0.00000E+00
LA5842       22987       27717      0.13674E-09
RA5843       27720       23040      0.53870E-02
VA5843       27719       27720 AC   0.00000E+00
LA5843       22990       27719      0.12767E-08
RA5844       27722       23043      0.53870E-02
VA5844       27721       27722 AC   0.00000E+00
LA5844       22993       27721      0.12767E-08
RA5845       27724       23046      0.53870E-02
VA5845       27723       27724 AC   0.00000E+00
LA5845       22996       27723      0.12767E-08
RA5846       27726       23049      0.53870E-02
VA5846       27725       27726 AC   0.00000E+00
LA5846       22999       27725      0.12767E-08
RA5847       27728       23052      0.53870E-02
VA5847       27727       27728 AC   0.00000E+00
LA5847       23002       27727      0.12767E-08
RA5848       27730       23055      0.53870E-02
VA5848       27729       27730 AC   0.00000E+00
LA5848       23005       27729      0.12767E-08
RA5849       27732       23058      0.53870E-02
VA5849       27731       27732 AC   0.00000E+00
LA5849       23008       27731      0.12767E-08
RA5850       27734       23061      0.53870E-02
VA5850       27733       27734 AC   0.00000E+00
LA5850       23011       27733      0.12767E-08
RA5851       27736       23064      0.53870E-02
VA5851       27735       27736 AC   0.00000E+00
LA5851       23014       27735      0.12767E-08
RA5852       27738       23067      0.53870E-02
VA5852       27737       27738 AC   0.00000E+00
LA5852       23017       27737      0.13674E-09
RA5853       27740       23068      0.53870E-02
VA5853       27739       27740 AC   0.00000E+00
LA5853       23018       27739      0.23931E-09
RA5854       27742       23071      0.53870E-02
VA5854       27741       27742 AC   0.00000E+00
LA5854       23021       27741      0.12767E-08
RA5855       27744       23074      0.53870E-02
VA5855       27743       27744 AC   0.00000E+00
LA5855       23024       27743      0.12767E-08
RA5856       27746       23077      0.53870E-02
VA5856       27745       27746 AC   0.00000E+00
LA5856       23027       27745      0.12767E-08
RA5857       27748       23080      0.53870E-02
VA5857       27747       27748 AC   0.00000E+00
LA5857       23030       27747      0.12767E-08
RA5858       27750       23083      0.53870E-02
VA5858       27749       27750 AC   0.00000E+00
LA5858       23033       27749      0.12767E-08
RA5859       27752       23086      0.53870E-02
VA5859       27751       27752 AC   0.00000E+00
LA5859       23036       27751      0.14613E-09
RA5860       27754       23087      0.53870E-02
VA5860       27753       27754 AC   0.00000E+00
LA5860       23037       27753      0.13674E-09
RA5861       27756       23090      0.53870E-02
VA5861       27755       27756 AC   0.00000E+00
LA5861       23040       27755      0.12767E-08
RA5862       27758       23093      0.53870E-02
VA5862       27757       27758 AC   0.00000E+00
LA5862       23043       27757      0.12767E-08
RA5863       27760       23096      0.53870E-02
VA5863       27759       27760 AC   0.00000E+00
LA5863       23046       27759      0.12767E-08
RA5864       27762       23099      0.53870E-02
VA5864       27761       27762 AC   0.00000E+00
LA5864       23049       27761      0.12767E-08
RA5865       27764       23102      0.53870E-02
VA5865       27763       27764 AC   0.00000E+00
LA5865       23052       27763      0.12767E-08
RA5866       27766       23105      0.53870E-02
VA5866       27765       27766 AC   0.00000E+00
LA5866       23055       27765      0.12767E-08
RA5867       27768       23108      0.53870E-02
VA5867       27767       27768 AC   0.00000E+00
LA5867       23058       27767      0.12767E-08
RA5868       27770       23111      0.53870E-02
VA5868       27769       27770 AC   0.00000E+00
LA5868       23061       27769      0.12767E-08
RA5869       27772       23114      0.53870E-02
VA5869       27771       27772 AC   0.00000E+00
LA5869       23064       27771      0.12767E-08
RA5870       27774       23117      0.53870E-02
VA5870       27773       27774 AC   0.00000E+00
LA5870       23067       27773      0.13674E-09
RA5871       27776       23118      0.53870E-02
VA5871       27775       27776 AC   0.00000E+00
LA5871       23068       27775      0.23931E-09
RA5872       27778       23121      0.53870E-02
VA5872       27777       27778 AC   0.00000E+00
LA5872       23071       27777      0.12767E-08
RA5873       27780       23124      0.53870E-02
VA5873       27779       27780 AC   0.00000E+00
LA5873       23074       27779      0.12767E-08
RA5874       27782       23127      0.53870E-02
VA5874       27781       27782 AC   0.00000E+00
LA5874       23077       27781      0.12767E-08
RA5875       27784       23130      0.53870E-02
VA5875       27783       27784 AC   0.00000E+00
LA5875       23080       27783      0.12767E-08
RA5876       27786       23133      0.53870E-02
VA5876       27785       27786 AC   0.00000E+00
LA5876       23083       27785      0.12767E-08
RA5877       27788       23136      0.53870E-02
VA5877       27787       27788 AC   0.00000E+00
LA5877       23086       27787      0.14613E-09
RA5878       27790       23137      0.53870E-02
VA5878       27789       27790 AC   0.00000E+00
LA5878       23087       27789      0.13674E-09
RA5879       27792       23140      0.53870E-02
VA5879       27791       27792 AC   0.00000E+00
LA5879       23090       27791      0.12767E-08
RA5880       27794       23143      0.53870E-02
VA5880       27793       27794 AC   0.00000E+00
LA5880       23093       27793      0.12767E-08
RA5881       27796       23146      0.53870E-02
VA5881       27795       27796 AC   0.00000E+00
LA5881       23096       27795      0.12767E-08
RA5882       27798       23149      0.53870E-02
VA5882       27797       27798 AC   0.00000E+00
LA5882       23099       27797      0.12767E-08
RA5883       27800       23152      0.53870E-02
VA5883       27799       27800 AC   0.00000E+00
LA5883       23102       27799      0.12767E-08
RA5884       27802       23155      0.53870E-02
VA5884       27801       27802 AC   0.00000E+00
LA5884       23105       27801      0.12767E-08
RA5885       27804       23158      0.53870E-02
VA5885       27803       27804 AC   0.00000E+00
LA5885       23108       27803      0.12767E-08
RA5886       27806       23161      0.53870E-02
VA5886       27805       27806 AC   0.00000E+00
LA5886       23111       27805      0.12767E-08
RA5887       27808       23164      0.53870E-02
VA5887       27807       27808 AC   0.00000E+00
LA5887       23114       27807      0.12767E-08
RA5888       27810       23167      0.53870E-02
VA5888       27809       27810 AC   0.00000E+00
LA5888       23117       27809      0.13674E-09
RA5889       27812       23168      0.53870E-02
VA5889       27811       27812 AC   0.00000E+00
LA5889       23118       27811      0.23931E-09
RA5890       27814       23171      0.53870E-02
VA5890       27813       27814 AC   0.00000E+00
LA5890       23121       27813      0.12767E-08
RA5891       27816       23174      0.53870E-02
VA5891       27815       27816 AC   0.00000E+00
LA5891       23124       27815      0.12767E-08
RA5892       27818       23177      0.53870E-02
VA5892       27817       27818 AC   0.00000E+00
LA5892       23127       27817      0.12767E-08
RA5893       27820       23180      0.53870E-02
VA5893       27819       27820 AC   0.00000E+00
LA5893       23130       27819      0.12767E-08
RA5894       27822       23183      0.53870E-02
VA5894       27821       27822 AC   0.00000E+00
LA5894       23133       27821      0.12767E-08
RA5895       27824       23186      0.53870E-02
VA5895       27823       27824 AC   0.00000E+00
LA5895       23136       27823      0.14613E-09
RA5896       27826       23187      0.53870E-02
VA5896       27825       27826 AC   0.00000E+00
LA5896       23137       27825      0.13674E-09
RA5897       27828       23190      0.53870E-02
VA5897       27827       27828 AC   0.00000E+00
LA5897       23140       27827      0.12767E-08
RA5898       27830       23193      0.53870E-02
VA5898       27829       27830 AC   0.00000E+00
LA5898       23143       27829      0.12767E-08
RA5899       27832       23196      0.53870E-02
VA5899       27831       27832 AC   0.00000E+00
LA5899       23146       27831      0.12767E-08
RA5900       27834       23199      0.53870E-02
VA5900       27833       27834 AC   0.00000E+00
LA5900       23149       27833      0.12767E-08
RA5901       27836       23202      0.53870E-02
VA5901       27835       27836 AC   0.00000E+00
LA5901       23152       27835      0.12767E-08
RA5902       27838       23205      0.53870E-02
VA5902       27837       27838 AC   0.00000E+00
LA5902       23155       27837      0.12767E-08
RA5903       27840       23208      0.53870E-02
VA5903       27839       27840 AC   0.00000E+00
LA5903       23158       27839      0.12767E-08
RA5904       27842       23211      0.53870E-02
VA5904       27841       27842 AC   0.00000E+00
LA5904       23161       27841      0.12767E-08
RA5905       27844       23214      0.53870E-02
VA5905       27843       27844 AC   0.00000E+00
LA5905       23164       27843      0.12767E-08
RA5906       27846       23217      0.53870E-02
VA5906       27845       27846 AC   0.00000E+00
LA5906       23167       27845      0.13674E-09
RA5907       27848       23218      0.53870E-02
VA5907       27847       27848 AC   0.00000E+00
LA5907       23168       27847      0.23931E-09
RA5908       27850       23221      0.53870E-02
VA5908       27849       27850 AC   0.00000E+00
LA5908       23171       27849      0.12767E-08
RA5909       27852       23224      0.53870E-02
VA5909       27851       27852 AC   0.00000E+00
LA5909       23174       27851      0.12767E-08
RA5910       27854       23227      0.53870E-02
VA5910       27853       27854 AC   0.00000E+00
LA5910       23177       27853      0.12767E-08
RA5911       27856       23230      0.53870E-02
VA5911       27855       27856 AC   0.00000E+00
LA5911       23180       27855      0.12767E-08
RA5912       27858       23233      0.53870E-02
VA5912       27857       27858 AC   0.00000E+00
LA5912       23183       27857      0.12767E-08
RA5913       27860       23236      0.53870E-02
VA5913       27859       27860 AC   0.00000E+00
LA5913       23186       27859      0.14613E-09
RA5914       27862       23237      0.53870E-02
VA5914       27861       27862 AC   0.00000E+00
LA5914       23187       27861      0.13674E-09
RA5915       27864       23240      0.53870E-02
VA5915       27863       27864 AC   0.00000E+00
LA5915       23190       27863      0.12767E-08
RA5916       27866       23243      0.53870E-02
VA5916       27865       27866 AC   0.00000E+00
LA5916       23193       27865      0.12767E-08
RA5917       27868       23246      0.53870E-02
VA5917       27867       27868 AC   0.00000E+00
LA5917       23196       27867      0.12767E-08
RA5918       27870       23249      0.53870E-02
VA5918       27869       27870 AC   0.00000E+00
LA5918       23199       27869      0.12767E-08
RA5919       27872       23252      0.53870E-02
VA5919       27871       27872 AC   0.00000E+00
LA5919       23202       27871      0.12767E-08
RA5920       27874       23255      0.53870E-02
VA5920       27873       27874 AC   0.00000E+00
LA5920       23205       27873      0.12767E-08
RA5921       27876       23258      0.53870E-02
VA5921       27875       27876 AC   0.00000E+00
LA5921       23208       27875      0.12767E-08
RA5922       27878       23261      0.53870E-02
VA5922       27877       27878 AC   0.00000E+00
LA5922       23211       27877      0.12767E-08
RA5923       27880       23264      0.53870E-02
VA5923       27879       27880 AC   0.00000E+00
LA5923       23214       27879      0.12767E-08
RA5924       27882       23267      0.53870E-02
VA5924       27881       27882 AC   0.00000E+00
LA5924       23217       27881      0.13674E-09
RA5925       27884       23268      0.53870E-02
VA5925       27883       27884 AC   0.00000E+00
LA5925       23218       27883      0.23931E-09
RA5926       27886       23271      0.53870E-02
VA5926       27885       27886 AC   0.00000E+00
LA5926       23221       27885      0.12767E-08
RA5927       27888       23274      0.53870E-02
VA5927       27887       27888 AC   0.00000E+00
LA5927       23224       27887      0.12767E-08
RA5928       27890       23277      0.53870E-02
VA5928       27889       27890 AC   0.00000E+00
LA5928       23227       27889      0.12767E-08
RA5929       27892       23280      0.53870E-02
VA5929       27891       27892 AC   0.00000E+00
LA5929       23230       27891      0.12767E-08
RA5930       27894       23283      0.53870E-02
VA5930       27893       27894 AC   0.00000E+00
LA5930       23233       27893      0.12767E-08
RA5931       27896       23286      0.53870E-02
VA5931       27895       27896 AC   0.00000E+00
LA5931       23236       27895      0.14613E-09
RA5932       27898       23287      0.53870E-02
VA5932       27897       27898 AC   0.00000E+00
LA5932       23237       27897      0.13674E-09
RA5933       27900       23290      0.53870E-02
VA5933       27899       27900 AC   0.00000E+00
LA5933       23240       27899      0.12767E-08
RA5934       27902       23293      0.53870E-02
VA5934       27901       27902 AC   0.00000E+00
LA5934       23243       27901      0.12767E-08
RA5935       27904       23296      0.53870E-02
VA5935       27903       27904 AC   0.00000E+00
LA5935       23246       27903      0.12767E-08
RA5936       27906       23299      0.53870E-02
VA5936       27905       27906 AC   0.00000E+00
LA5936       23249       27905      0.12767E-08
RA5937       27908       23302      0.53870E-02
VA5937       27907       27908 AC   0.00000E+00
LA5937       23252       27907      0.12767E-08
RA5938       27910       23305      0.53870E-02
VA5938       27909       27910 AC   0.00000E+00
LA5938       23255       27909      0.12767E-08
RA5939       27912       23308      0.53870E-02
VA5939       27911       27912 AC   0.00000E+00
LA5939       23258       27911      0.12767E-08
RA5940       27914       23311      0.53870E-02
VA5940       27913       27914 AC   0.00000E+00
LA5940       23261       27913      0.12767E-08
RA5941       27916       23314      0.53870E-02
VA5941       27915       27916 AC   0.00000E+00
LA5941       23264       27915      0.12767E-08
RA5942       27918       23317      0.53870E-02
VA5942       27917       27918 AC   0.00000E+00
LA5942       23267       27917      0.13674E-09
RA5943       27920       23318      0.53870E-02
VA5943       27919       27920 AC   0.00000E+00
LA5943       23268       27919      0.23931E-09
RA5944       27922       23321      0.53870E-02
VA5944       27921       27922 AC   0.00000E+00
LA5944       23271       27921      0.12767E-08
RA5945       27924       23324      0.53870E-02
VA5945       27923       27924 AC   0.00000E+00
LA5945       23274       27923      0.12767E-08
RA5946       27926       23327      0.53870E-02
VA5946       27925       27926 AC   0.00000E+00
LA5946       23277       27925      0.12767E-08
RA5947       27928       23330      0.53870E-02
VA5947       27927       27928 AC   0.00000E+00
LA5947       23280       27927      0.12767E-08
RA5948       27930       23333      0.53870E-02
VA5948       27929       27930 AC   0.00000E+00
LA5948       23283       27929      0.12767E-08
RA5949       27932       23336      0.53870E-02
VA5949       27931       27932 AC   0.00000E+00
LA5949       23286       27931      0.14613E-09
RA5950       27934       23337      0.53870E-02
VA5950       27933       27934 AC   0.00000E+00
LA5950       23287       27933      0.13674E-09
RA5951       27936       23340      0.53870E-02
VA5951       27935       27936 AC   0.00000E+00
LA5951       23290       27935      0.12767E-08
RA5952       27938       23343      0.53870E-02
VA5952       27937       27938 AC   0.00000E+00
LA5952       23293       27937      0.12767E-08
RA5953       27940       23346      0.53870E-02
VA5953       27939       27940 AC   0.00000E+00
LA5953       23296       27939      0.12767E-08
RA5954       27942       23349      0.53870E-02
VA5954       27941       27942 AC   0.00000E+00
LA5954       23299       27941      0.12767E-08
RA5955       27944       23352      0.53870E-02
VA5955       27943       27944 AC   0.00000E+00
LA5955       23302       27943      0.12767E-08
RA5956       27946       23355      0.53870E-02
VA5956       27945       27946 AC   0.00000E+00
LA5956       23305       27945      0.12767E-08
RA5957       27948       23358      0.53870E-02
VA5957       27947       27948 AC   0.00000E+00
LA5957       23308       27947      0.12767E-08
RA5958       27950       23361      0.53870E-02
VA5958       27949       27950 AC   0.00000E+00
LA5958       23311       27949      0.12767E-08
RA5959       27952       23364      0.53870E-02
VA5959       27951       27952 AC   0.00000E+00
LA5959       23314       27951      0.12767E-08
RA5960       27954       23367      0.53870E-02
VA5960       27953       27954 AC   0.00000E+00
LA5960       23317       27953      0.13674E-09
RA5961       27956       23368      0.53870E-02
VA5961       27955       27956 AC   0.00000E+00
LA5961       23318       27955      0.23931E-09
RA5962       27958       23371      0.53870E-02
VA5962       27957       27958 AC   0.00000E+00
LA5962       23321       27957      0.12767E-08
RA5963       27960       23374      0.53870E-02
VA5963       27959       27960 AC   0.00000E+00
LA5963       23324       27959      0.12767E-08
RA5964       27962       23377      0.53870E-02
VA5964       27961       27962 AC   0.00000E+00
LA5964       23327       27961      0.12767E-08
RA5965       27964       23380      0.53870E-02
VA5965       27963       27964 AC   0.00000E+00
LA5965       23330       27963      0.12767E-08
RA5966       27966       23383      0.53870E-02
VA5966       27965       27966 AC   0.00000E+00
LA5966       23333       27965      0.12767E-08
RA5967       27968       23386      0.53870E-02
VA5967       27967       27968 AC   0.00000E+00
LA5967       23336       27967      0.14613E-09
RA5968       27970       23387      0.53870E-02
VA5968       27969       27970 AC   0.00000E+00
LA5968       23337       27969      0.13674E-09
RA5969       27972       23390      0.53870E-02
VA5969       27971       27972 AC   0.00000E+00
LA5969       23340       27971      0.12767E-08
RA5970       27974       23393      0.53870E-02
VA5970       27973       27974 AC   0.00000E+00
LA5970       23343       27973      0.12767E-08
RA5971       27976       23396      0.53870E-02
VA5971       27975       27976 AC   0.00000E+00
LA5971       23346       27975      0.12767E-08
RA5972       27978       23399      0.53870E-02
VA5972       27977       27978 AC   0.00000E+00
LA5972       23349       27977      0.12767E-08
RA5973       27980       23402      0.53870E-02
VA5973       27979       27980 AC   0.00000E+00
LA5973       23352       27979      0.12767E-08
RA5974       27982       23405      0.53870E-02
VA5974       27981       27982 AC   0.00000E+00
LA5974       23355       27981      0.12767E-08
RA5975       27984       23408      0.53870E-02
VA5975       27983       27984 AC   0.00000E+00
LA5975       23358       27983      0.12767E-08
RA5976       27986       23411      0.53870E-02
VA5976       27985       27986 AC   0.00000E+00
LA5976       23361       27985      0.12767E-08
RA5977       27988       23414      0.53870E-02
VA5977       27987       27988 AC   0.00000E+00
LA5977       23364       27987      0.12767E-08
RA5978       27990       23417      0.53870E-02
VA5978       27989       27990 AC   0.00000E+00
LA5978       23367       27989      0.13674E-09
RA5979       27992       23418      0.53870E-02
VA5979       27991       27992 AC   0.00000E+00
LA5979       23368       27991      0.23931E-09
RA5980       27994       23421      0.53870E-02
VA5980       27993       27994 AC   0.00000E+00
LA5980       23371       27993      0.12767E-08
RA5981       27996       23424      0.53870E-02
VA5981       27995       27996 AC   0.00000E+00
LA5981       23374       27995      0.12767E-08
RA5982       27998       23427      0.53870E-02
VA5982       27997       27998 AC   0.00000E+00
LA5982       23377       27997      0.12767E-08
RA5983       28000       23430      0.53870E-02
VA5983       27999       28000 AC   0.00000E+00
LA5983       23380       27999      0.12767E-08
RA5984       28002       23433      0.53870E-02
VA5984       28001       28002 AC   0.00000E+00
LA5984       23383       28001      0.12767E-08
RA5985       28004       23436      0.53870E-02
VA5985       28003       28004 AC   0.00000E+00
LA5985       23386       28003      0.14613E-09
RA5986       28006       23437      0.53870E-02
VA5986       28005       28006 AC   0.00000E+00
LA5986       23387       28005      0.13674E-09
RA5987       28008       23440      0.53870E-02
VA5987       28007       28008 AC   0.00000E+00
LA5987       23390       28007      0.12767E-08
RA5988       28010       23443      0.53870E-02
VA5988       28009       28010 AC   0.00000E+00
LA5988       23393       28009      0.12767E-08
RA5989       28012       23446      0.53870E-02
VA5989       28011       28012 AC   0.00000E+00
LA5989       23396       28011      0.12767E-08
RA5990       28014       23449      0.53870E-02
VA5990       28013       28014 AC   0.00000E+00
LA5990       23399       28013      0.12767E-08
RA5991       28016       23452      0.53870E-02
VA5991       28015       28016 AC   0.00000E+00
LA5991       23402       28015      0.12767E-08
RA5992       28018       23455      0.53870E-02
VA5992       28017       28018 AC   0.00000E+00
LA5992       23405       28017      0.12767E-08
RA5993       28020       23458      0.53870E-02
VA5993       28019       28020 AC   0.00000E+00
LA5993       23408       28019      0.12767E-08
RA5994       28022       23461      0.53870E-02
VA5994       28021       28022 AC   0.00000E+00
LA5994       23411       28021      0.12767E-08
RA5995       28024       23464      0.53870E-02
VA5995       28023       28024 AC   0.00000E+00
LA5995       23414       28023      0.12767E-08
RA5996       28026       23467      0.53870E-02
VA5996       28025       28026 AC   0.00000E+00
LA5996       23417       28025      0.13674E-09
RA5997       28028       23468      0.53870E-02
VA5997       28027       28028 AC   0.00000E+00
LA5997       23418       28027      0.23931E-09
RA5998       28030       23471      0.53870E-02
VA5998       28029       28030 AC   0.00000E+00
LA5998       23421       28029      0.12767E-08
RA5999       28032       23474      0.53870E-02
VA5999       28031       28032 AC   0.00000E+00
LA5999       23424       28031      0.12767E-08
RA6000       28034       23477      0.53870E-02
VA6000       28033       28034 AC   0.00000E+00
LA6000       23427       28033      0.12767E-08
RA6001       28036       23480      0.53870E-02
VA6001       28035       28036 AC   0.00000E+00
LA6001       23430       28035      0.12767E-08
RA6002       28038       23483      0.53870E-02
VA6002       28037       28038 AC   0.00000E+00
LA6002       23433       28037      0.12767E-08
RA6003       28040       23486      0.53870E-02
VA6003       28039       28040 AC   0.00000E+00
LA6003       23436       28039      0.14613E-09
RA6004       28042       23487      0.53870E-02
VA6004       28041       28042 AC   0.00000E+00
LA6004       23437       28041      0.13674E-09
RA6005       28044       23490      0.53870E-02
VA6005       28043       28044 AC   0.00000E+00
LA6005       23440       28043      0.12767E-08
RA6006       28046       23493      0.53870E-02
VA6006       28045       28046 AC   0.00000E+00
LA6006       23443       28045      0.12767E-08
RA6007       28048       23496      0.53870E-02
VA6007       28047       28048 AC   0.00000E+00
LA6007       23446       28047      0.12767E-08
RA6008       28050       23499      0.53870E-02
VA6008       28049       28050 AC   0.00000E+00
LA6008       23449       28049      0.12767E-08
RA6009       28052       23502      0.53870E-02
VA6009       28051       28052 AC   0.00000E+00
LA6009       23452       28051      0.12767E-08
RA6010       28054       23505      0.53870E-02
VA6010       28053       28054 AC   0.00000E+00
LA6010       23455       28053      0.12767E-08
RA6011       28056       23508      0.53870E-02
VA6011       28055       28056 AC   0.00000E+00
LA6011       23458       28055      0.12767E-08
RA6012       28058       23511      0.53870E-02
VA6012       28057       28058 AC   0.00000E+00
LA6012       23461       28057      0.12767E-08
RA6013       28060       23514      0.53870E-02
VA6013       28059       28060 AC   0.00000E+00
LA6013       23464       28059      0.12767E-08
RA6014       28062       23517      0.53870E-02
VA6014       28061       28062 AC   0.00000E+00
LA6014       23467       28061      0.13674E-09
RA6015       28064       23518      0.53870E-02
VA6015       28063       28064 AC   0.00000E+00
LA6015       23468       28063      0.23931E-09
RA6016       28066       23521      0.53870E-02
VA6016       28065       28066 AC   0.00000E+00
LA6016       23471       28065      0.12767E-08
RA6017       28068       23524      0.53870E-02
VA6017       28067       28068 AC   0.00000E+00
LA6017       23474       28067      0.12767E-08
RA6018       28070       23527      0.53870E-02
VA6018       28069       28070 AC   0.00000E+00
LA6018       23477       28069      0.12767E-08
RA6019       28072       23530      0.53870E-02
VA6019       28071       28072 AC   0.00000E+00
LA6019       23480       28071      0.12767E-08
RA6020       28074       23533      0.53870E-02
VA6020       28073       28074 AC   0.00000E+00
LA6020       23483       28073      0.12767E-08
RA6021       28076       23536      0.53870E-02
VA6021       28075       28076 AC   0.00000E+00
LA6021       23486       28075      0.14613E-09
RA6022       28078       23537      0.53870E-02
VA6022       28077       28078 AC   0.00000E+00
LA6022       23487       28077      0.13674E-09
RA6023       28080       23540      0.53870E-02
VA6023       28079       28080 AC   0.00000E+00
LA6023       23490       28079      0.12767E-08
RA6024       28082       23543      0.53870E-02
VA6024       28081       28082 AC   0.00000E+00
LA6024       23493       28081      0.12767E-08
RA6025       28084       23546      0.53870E-02
VA6025       28083       28084 AC   0.00000E+00
LA6025       23496       28083      0.12767E-08
RA6026       28086       23549      0.53870E-02
VA6026       28085       28086 AC   0.00000E+00
LA6026       23499       28085      0.12767E-08
RA6027       28088       23552      0.53870E-02
VA6027       28087       28088 AC   0.00000E+00
LA6027       23502       28087      0.12767E-08
RA6028       28090       23555      0.53870E-02
VA6028       28089       28090 AC   0.00000E+00
LA6028       23505       28089      0.12767E-08
RA6029       28092       23558      0.53870E-02
VA6029       28091       28092 AC   0.00000E+00
LA6029       23508       28091      0.12767E-08
RA6030       28094       23561      0.53870E-02
VA6030       28093       28094 AC   0.00000E+00
LA6030       23511       28093      0.12767E-08
RA6031       28096       23564      0.53870E-02
VA6031       28095       28096 AC   0.00000E+00
LA6031       23514       28095      0.12767E-08
RA6032       28098       23567      0.53870E-02
VA6032       28097       28098 AC   0.00000E+00
LA6032       23517       28097      0.13674E-09
RA6033       28100       23568      0.53870E-02
VA6033       28099       28100 AC   0.00000E+00
LA6033       23518       28099      0.23931E-09
RA6034       28102       23571      0.53870E-02
VA6034       28101       28102 AC   0.00000E+00
LA6034       23521       28101      0.12767E-08
RA6035       28104       23574      0.53870E-02
VA6035       28103       28104 AC   0.00000E+00
LA6035       23524       28103      0.12767E-08
RA6036       28106       23577      0.53870E-02
VA6036       28105       28106 AC   0.00000E+00
LA6036       23527       28105      0.12767E-08
RA6037       28108       23580      0.53870E-02
VA6037       28107       28108 AC   0.00000E+00
LA6037       23530       28107      0.12767E-08
RA6038       28110       23583      0.53870E-02
VA6038       28109       28110 AC   0.00000E+00
LA6038       23533       28109      0.12767E-08
RA6039       28112       23586      0.53870E-02
VA6039       28111       28112 AC   0.00000E+00
LA6039       23536       28111      0.14613E-09
RA6040       28114       23587      0.53870E-02
VA6040       28113       28114 AC   0.00000E+00
LA6040       23537       28113      0.13674E-09
RA6041       28116       23590      0.53870E-02
VA6041       28115       28116 AC   0.00000E+00
LA6041       23540       28115      0.12767E-08
RA6042       28118       23593      0.53870E-02
VA6042       28117       28118 AC   0.00000E+00
LA6042       23543       28117      0.12767E-08
RA6043       28120       23596      0.53870E-02
VA6043       28119       28120 AC   0.00000E+00
LA6043       23546       28119      0.12767E-08
RA6044       28122       23599      0.53870E-02
VA6044       28121       28122 AC   0.00000E+00
LA6044       23549       28121      0.12767E-08
RA6045       28124       23602      0.53870E-02
VA6045       28123       28124 AC   0.00000E+00
LA6045       23552       28123      0.12767E-08
RA6046       28126       23605      0.53870E-02
VA6046       28125       28126 AC   0.00000E+00
LA6046       23555       28125      0.12767E-08
RA6047       28128       23608      0.53870E-02
VA6047       28127       28128 AC   0.00000E+00
LA6047       23558       28127      0.12767E-08
RA6048       28130       23611      0.53870E-02
VA6048       28129       28130 AC   0.00000E+00
LA6048       23561       28129      0.12767E-08
RA6049       28132       23614      0.53870E-02
VA6049       28131       28132 AC   0.00000E+00
LA6049       23564       28131      0.12767E-08
RA6050       28134       23617      0.53870E-02
VA6050       28133       28134 AC   0.00000E+00
LA6050       23567       28133      0.13674E-09
RA6051       28136       23618      0.53870E-02
VA6051       28135       28136 AC   0.00000E+00
LA6051       23587       28135      0.13674E-09
RA6052       28138       23621      0.53870E-02
VA6052       28137       28138 AC   0.00000E+00
LA6052       23590       28137      0.12767E-08
RA6053       28140       23624      0.53870E-02
VA6053       28139       28140 AC   0.00000E+00
LA6053       23593       28139      0.12767E-08
RA6054       28142       23627      0.53870E-02
VA6054       28141       28142 AC   0.00000E+00
LA6054       23596       28141      0.12767E-08
RA6055       28144       23630      0.53870E-02
VA6055       28143       28144 AC   0.00000E+00
LA6055       23599       28143      0.12767E-08
RA6056       28146       23633      0.53870E-02
VA6056       28145       28146 AC   0.00000E+00
LA6056       23602       28145      0.12767E-08
RA6057       28148       23636      0.53870E-02
VA6057       28147       28148 AC   0.00000E+00
LA6057       23605       28147      0.12767E-08
RA6058       28150       23639      0.53870E-02
VA6058       28149       28150 AC   0.00000E+00
LA6058       23608       28149      0.12767E-08
RA6059       28152       23642      0.53870E-02
VA6059       28151       28152 AC   0.00000E+00
LA6059       23611       28151      0.12767E-08
RA6060       28154       23645      0.53870E-02
VA6060       28153       28154 AC   0.00000E+00
LA6060       23614       28153      0.12767E-08
RA6061       28156       23648      0.53870E-02
VA6061       28155       28156 AC   0.00000E+00
LA6061       23617       28155      0.13674E-09
RA6062       28158       23649      0.53870E-02
VA6062       28157       28158 AC   0.00000E+00
LA6062       23618       28157      0.13674E-09
RA6063       28160       23652      0.53870E-02
VA6063       28159       28160 AC   0.00000E+00
LA6063       23621       28159      0.12767E-08
RA6064       28162       23655      0.53870E-02
VA6064       28161       28162 AC   0.00000E+00
LA6064       23624       28161      0.12767E-08
RA6065       28164       23658      0.53870E-02
VA6065       28163       28164 AC   0.00000E+00
LA6065       23627       28163      0.12767E-08
RA6066       28166       23661      0.53870E-02
VA6066       28165       28166 AC   0.00000E+00
LA6066       23630       28165      0.12767E-08
RA6067       28168       23664      0.53870E-02
VA6067       28167       28168 AC   0.00000E+00
LA6067       23633       28167      0.12767E-08
RA6068       28170       23667      0.53870E-02
VA6068       28169       28170 AC   0.00000E+00
LA6068       23636       28169      0.12767E-08
RA6069       28172       23670      0.53870E-02
VA6069       28171       28172 AC   0.00000E+00
LA6069       23639       28171      0.12767E-08
RA6070       28174       23673      0.53870E-02
VA6070       28173       28174 AC   0.00000E+00
LA6070       23642       28173      0.12767E-08
RA6071       28176       23676      0.53870E-02
VA6071       28175       28176 AC   0.00000E+00
LA6071       23645       28175      0.12767E-08
RA6072       28178       23679      0.53870E-02
VA6072       28177       28178 AC   0.00000E+00
LA6072       23648       28177      0.13674E-09
RA6073       28180       23680      0.53870E-02
VA6073       28179       28180 AC   0.00000E+00
LA6073       23649       28179      0.13674E-09
RA6074       28182       23683      0.53870E-02
VA6074       28181       28182 AC   0.00000E+00
LA6074       23652       28181      0.12767E-08
RA6075       28184       23686      0.53870E-02
VA6075       28183       28184 AC   0.00000E+00
LA6075       23655       28183      0.12767E-08
RA6076       28186       23689      0.53870E-02
VA6076       28185       28186 AC   0.00000E+00
LA6076       23658       28185      0.12767E-08
RA6077       28188       23692      0.53870E-02
VA6077       28187       28188 AC   0.00000E+00
LA6077       23661       28187      0.12767E-08
RA6078       28190       23695      0.53870E-02
VA6078       28189       28190 AC   0.00000E+00
LA6078       23664       28189      0.12767E-08
RA6079       28192       23698      0.53870E-02
VA6079       28191       28192 AC   0.00000E+00
LA6079       23667       28191      0.12767E-08
RA6080       28194       23701      0.53870E-02
VA6080       28193       28194 AC   0.00000E+00
LA6080       23670       28193      0.12767E-08
RA6081       28196       23704      0.53870E-02
VA6081       28195       28196 AC   0.00000E+00
LA6081       23673       28195      0.12767E-08
RA6082       28198       23707      0.53870E-02
VA6082       28197       28198 AC   0.00000E+00
LA6082       23676       28197      0.12767E-08
RA6083       28200       23710      0.53870E-02
VA6083       28199       28200 AC   0.00000E+00
LA6083       23679       28199      0.13674E-09
RA6084       28202       23740      0.53870E-02
VA6084       28201       28202 AC   0.00000E+00
LA6084       23680       28201      0.70672E-09
RA6085       28204       23743      0.53870E-02
VA6085       28203       28204 AC   0.00000E+00
LA6085       23683       28203      0.12767E-08
RA6086       28206       23746      0.53870E-02
VA6086       28205       28206 AC   0.00000E+00
LA6086       23686       28205      0.12767E-08
RA6087       28208       23749      0.53870E-02
VA6087       28207       28208 AC   0.00000E+00
LA6087       23689       28207      0.12767E-08
RA6088       28210       23752      0.53870E-02
VA6088       28209       28210 AC   0.00000E+00
LA6088       23692       28209      0.12767E-08
RA6089       28212       23755      0.53870E-02
VA6089       28211       28212 AC   0.00000E+00
LA6089       23695       28211      0.12767E-08
RA6090       28214       23758      0.53870E-02
VA6090       28213       28214 AC   0.00000E+00
LA6090       23698       28213      0.12767E-08
RA6091       28216       23761      0.53870E-02
VA6091       28215       28216 AC   0.00000E+00
LA6091       23701       28215      0.12767E-08
RA6092       28218       23764      0.53870E-02
VA6092       28217       28218 AC   0.00000E+00
LA6092       23704       28217      0.12767E-08
RA6093       28220       23767      0.53870E-02
VA6093       28219       28220 AC   0.00000E+00
LA6093       23707       28219      0.12767E-08
RA6094       28222       23770      0.53870E-02
VA6094       28221       28222 AC   0.00000E+00
LA6094       23710       28221      0.13076E-09
RA6095       28224       23773      0.53870E-02
VA6095       28223       28224 AC   0.00000E+00
LA6095       23713       28223      0.12767E-08
RA6096       28226       23776      0.53870E-02
VA6096       28225       28226 AC   0.00000E+00
LA6096       23716       28225      0.12767E-08
RA6097       28228       23779      0.53870E-02
VA6097       28227       28228 AC   0.00000E+00
LA6097       23719       28227      0.12767E-08
RA6098       28230       23782      0.53870E-02
VA6098       28229       28230 AC   0.00000E+00
LA6098       23722       28229      0.12767E-08
RA6099       28232       23785      0.53870E-02
VA6099       28231       28232 AC   0.00000E+00
LA6099       23725       28231      0.12767E-08
RA6100       28234       23788      0.53870E-02
VA6100       28233       28234 AC   0.00000E+00
LA6100       23728       28233      0.12767E-08
RA6101       28236       23791      0.53870E-02
VA6101       28235       28236 AC   0.00000E+00
LA6101       23731       28235      0.12767E-08
RA6102       28238       23794      0.53870E-02
VA6102       28237       28238 AC   0.00000E+00
LA6102       23734       28237      0.12767E-08
RA6103       28240       23797      0.53870E-02
VA6103       28239       28240 AC   0.00000E+00
LA6103       23737       28239      0.12767E-08
RA6104       28242       23800      0.53870E-02
VA6104       28241       28242 AC   0.00000E+00
LA6104       23740       28241      0.12767E-08
RA6105       28244       23803      0.53870E-02
VA6105       28243       28244 AC   0.00000E+00
LA6105       23743       28243      0.12767E-08
RA6106       28246       23806      0.53870E-02
VA6106       28245       28246 AC   0.00000E+00
LA6106       23746       28245      0.12767E-08
RA6107       28248       23809      0.53870E-02
VA6107       28247       28248 AC   0.00000E+00
LA6107       23749       28247      0.12767E-08
RA6108       28250       23812      0.53870E-02
VA6108       28249       28250 AC   0.00000E+00
LA6108       23752       28249      0.12767E-08
RA6109       28252       23815      0.53870E-02
VA6109       28251       28252 AC   0.00000E+00
LA6109       23755       28251      0.12767E-08
RA6110       28254       23818      0.53870E-02
VA6110       28253       28254 AC   0.00000E+00
LA6110       23758       28253      0.12767E-08
RA6111       28256       23821      0.53870E-02
VA6111       28255       28256 AC   0.00000E+00
LA6111       23761       28255      0.12767E-08
RA6112       28258       23824      0.53870E-02
VA6112       28257       28258 AC   0.00000E+00
LA6112       23764       28257      0.12767E-08
RA6113       28260       23827      0.53870E-02
VA6113       28259       28260 AC   0.00000E+00
LA6113       23767       28259      0.12767E-08
RA6114       28262       23830      0.53870E-02
VA6114       28261       28262 AC   0.00000E+00
LA6114       23770       28261      0.12477E-09
RA6115       28264       23833      0.53870E-02
VA6115       28263       28264 AC   0.00000E+00
LA6115       23773       28263      0.12767E-08
RA6116       28266       23836      0.53870E-02
VA6116       28265       28266 AC   0.00000E+00
LA6116       23776       28265      0.12767E-08
RA6117       28268       23839      0.53870E-02
VA6117       28267       28268 AC   0.00000E+00
LA6117       23779       28267      0.12767E-08
RA6118       28270       23842      0.53870E-02
VA6118       28269       28270 AC   0.00000E+00
LA6118       23782       28269      0.12767E-08
RA6119       28272       23845      0.53870E-02
VA6119       28271       28272 AC   0.00000E+00
LA6119       23785       28271      0.12767E-08
RA6120       28274       23848      0.53870E-02
VA6120       28273       28274 AC   0.00000E+00
LA6120       23788       28273      0.12767E-08
RA6121       28276       23851      0.53870E-02
VA6121       28275       28276 AC   0.00000E+00
LA6121       23791       28275      0.12767E-08
RA6122       28278       23854      0.53870E-02
VA6122       28277       28278 AC   0.00000E+00
LA6122       23794       28277      0.12767E-08
RA6123       28280       23857      0.53870E-02
VA6123       28279       28280 AC   0.00000E+00
LA6123       23797       28279      0.12767E-08
RA6124       28282       23860      0.53870E-02
VA6124       28281       28282 AC   0.00000E+00
LA6124       23800       28281      0.12767E-08
RA6125       28284       23863      0.53870E-02
VA6125       28283       28284 AC   0.00000E+00
LA6125       23803       28283      0.12767E-08
RA6126       28286       23866      0.53870E-02
VA6126       28285       28286 AC   0.00000E+00
LA6126       23806       28285      0.12767E-08
RA6127       28288       23869      0.53870E-02
VA6127       28287       28288 AC   0.00000E+00
LA6127       23809       28287      0.12767E-08
RA6128       28290       23872      0.53870E-02
VA6128       28289       28290 AC   0.00000E+00
LA6128       23812       28289      0.12767E-08
RA6129       28292       23875      0.53870E-02
VA6129       28291       28292 AC   0.00000E+00
LA6129       23815       28291      0.12767E-08
RA6130       28294       23878      0.53870E-02
VA6130       28293       28294 AC   0.00000E+00
LA6130       23818       28293      0.12767E-08
RA6131       28296       23881      0.53870E-02
VA6131       28295       28296 AC   0.00000E+00
LA6131       23821       28295      0.12767E-08
RA6132       28298       23884      0.53870E-02
VA6132       28297       28298 AC   0.00000E+00
LA6132       23824       28297      0.12767E-08
RA6133       28300       23887      0.53870E-02
VA6133       28299       28300 AC   0.00000E+00
LA6133       23827       28299      0.12767E-08
RA6134       28302       23890      0.53870E-02
VA6134       28301       28302 AC   0.00000E+00
LA6134       23830       28301      0.12477E-09
RA6135       28304       23933      0.53870E-02
VA6135       28303       28304 AC   0.00000E+00
LA6135       23833       28303      0.12767E-08
RA6136       28306       23936      0.53870E-02
VA6136       28305       28306 AC   0.00000E+00
LA6136       23836       28305      0.12767E-08
RA6137       28308       23939      0.53870E-02
VA6137       28307       28308 AC   0.00000E+00
LA6137       23839       28307      0.12767E-08
RA6138       28310       23942      0.53870E-02
VA6138       28309       28310 AC   0.00000E+00
LA6138       23842       28309      0.12767E-08
RA6139       28312       23945      0.53870E-02
VA6139       28311       28312 AC   0.00000E+00
LA6139       23845       28311      0.12767E-08
RA6140       28314       23948      0.53870E-02
VA6140       28313       28314 AC   0.00000E+00
LA6140       23848       28313      0.12767E-08
RA6141       28316       23951      0.53870E-02
VA6141       28315       28316 AC   0.00000E+00
LA6141       23851       28315      0.12767E-08
RA6142       28318       23954      0.53870E-02
VA6142       28317       28318 AC   0.00000E+00
LA6142       23854       28317      0.12767E-08
RA6143       28320       23957      0.53870E-02
VA6143       28319       28320 AC   0.00000E+00
LA6143       23857       28319      0.12767E-08
RA6144       28322       23960      0.53870E-02
VA6144       28321       28322 AC   0.00000E+00
LA6144       23860       28321      0.12767E-08
RA6145       28324       23963      0.53870E-02
VA6145       28323       28324 AC   0.00000E+00
LA6145       23863       28323      0.12767E-08
RA6146       28326       23966      0.53870E-02
VA6146       28325       28326 AC   0.00000E+00
LA6146       23866       28325      0.12767E-08
RA6147       28328       23969      0.53870E-02
VA6147       28327       28328 AC   0.00000E+00
LA6147       23869       28327      0.12767E-08
RA6148       28330       23972      0.53870E-02
VA6148       28329       28330 AC   0.00000E+00
LA6148       23872       28329      0.12767E-08
RA6149       28332       23975      0.53870E-02
VA6149       28331       28332 AC   0.00000E+00
LA6149       23875       28331      0.12767E-08
RA6150       28334       23978      0.53870E-02
VA6150       28333       28334 AC   0.00000E+00
LA6150       23878       28333      0.12767E-08
RA6151       28336       23981      0.53870E-02
VA6151       28335       28336 AC   0.00000E+00
LA6151       23881       28335      0.12767E-08
RA6152       28338       23984      0.53870E-02
VA6152       28337       28338 AC   0.00000E+00
LA6152       23884       28337      0.12767E-08
RA6153       28340       23987      0.53870E-02
VA6153       28339       28340 AC   0.00000E+00
LA6153       23887       28339      0.12767E-08
RA6154       28342       23990      0.53870E-02
VA6154       28341       28342 AC   0.00000E+00
LA6154       23890       28341      0.12477E-09
RA6155       28344       23991      0.53870E-02
VA6155       28343       28344 AC   0.00000E+00
LA6155       23891       28343      0.13203E-09
RA6156       28346       23994      0.53870E-02
VA6156       28345       28346 AC   0.00000E+00
LA6156       23894       28345      0.12767E-08
RA6157       28348       23997      0.53870E-02
VA6157       28347       28348 AC   0.00000E+00
LA6157       23897       28347      0.12767E-08
RA6158       28350       24000      0.53870E-02
VA6158       28349       28350 AC   0.00000E+00
LA6158       23900       28349      0.12767E-08
RA6159       28352       24003      0.53870E-02
VA6159       28351       28352 AC   0.00000E+00
LA6159       23903       28351      0.12767E-08
RA6160       28354       24006      0.53870E-02
VA6160       28353       28354 AC   0.00000E+00
LA6160       23906       28353      0.12767E-08
RA6161       28356       24009      0.53870E-02
VA6161       28355       28356 AC   0.00000E+00
LA6161       23909       28355      0.12767E-08
RA6162       28358       24012      0.53870E-02
VA6162       28357       28358 AC   0.00000E+00
LA6162       23912       28357      0.12767E-08
RA6163       28360       24015      0.53870E-02
VA6163       28359       28360 AC   0.00000E+00
LA6163       23915       28359      0.12767E-08
RA6164       28362       24018      0.53870E-02
VA6164       28361       28362 AC   0.00000E+00
LA6164       23918       28361      0.12767E-08
RA6165       28364       24021      0.53870E-02
VA6165       28363       28364 AC   0.00000E+00
LA6165       23921       28363      0.12767E-08
RA6166       28366       24024      0.53870E-02
VA6166       28365       28366 AC   0.00000E+00
LA6166       23924       28365      0.12767E-08
RA6167       28368       24027      0.53870E-02
VA6167       28367       28368 AC   0.00000E+00
LA6167       23927       28367      0.12767E-08
RA6168       28370       24030      0.53870E-02
VA6168       28369       28370 AC   0.00000E+00
LA6168       23930       28369      0.21575E-09
RA6169       28372       24033      0.53870E-02
VA6169       28371       28372 AC   0.00000E+00
LA6169       23933       28371      0.12767E-08
RA6170       28374       24036      0.53870E-02
VA6170       28373       28374 AC   0.00000E+00
LA6170       23936       28373      0.12767E-08
RA6171       28376       24039      0.53870E-02
VA6171       28375       28376 AC   0.00000E+00
LA6171       23939       28375      0.12767E-08
RA6172       28378       24042      0.53870E-02
VA6172       28377       28378 AC   0.00000E+00
LA6172       23942       28377      0.12767E-08
RA6173       28380       24045      0.53870E-02
VA6173       28379       28380 AC   0.00000E+00
LA6173       23945       28379      0.12767E-08
RA6174       28382       24048      0.53870E-02
VA6174       28381       28382 AC   0.00000E+00
LA6174       23948       28381      0.12767E-08
RA6175       28384       24051      0.53870E-02
VA6175       28383       28384 AC   0.00000E+00
LA6175       23951       28383      0.12767E-08
RA6176       28386       24054      0.53870E-02
VA6176       28385       28386 AC   0.00000E+00
LA6176       23954       28385      0.12767E-08
RA6177       28388       24057      0.53870E-02
VA6177       28387       28388 AC   0.00000E+00
LA6177       23957       28387      0.12767E-08
RA6178       28390       24060      0.53870E-02
VA6178       28389       28390 AC   0.00000E+00
LA6178       23960       28389      0.12767E-08
RA6179       28392       24063      0.53870E-02
VA6179       28391       28392 AC   0.00000E+00
LA6179       23963       28391      0.12767E-08
RA6180       28394       24066      0.53870E-02
VA6180       28393       28394 AC   0.00000E+00
LA6180       23966       28393      0.12767E-08
RA6181       28396       24069      0.53870E-02
VA6181       28395       28396 AC   0.00000E+00
LA6181       23969       28395      0.12767E-08
RA6182       28398       24072      0.53870E-02
VA6182       28397       28398 AC   0.00000E+00
LA6182       23972       28397      0.12767E-08
RA6183       28400       24075      0.53870E-02
VA6183       28399       28400 AC   0.00000E+00
LA6183       23975       28399      0.12767E-08
RA6184       28402       24078      0.53870E-02
VA6184       28401       28402 AC   0.00000E+00
LA6184       23978       28401      0.12767E-08
RA6185       28404       24081      0.53870E-02
VA6185       28403       28404 AC   0.00000E+00
LA6185       23981       28403      0.12767E-08
RA6186       28406       24084      0.53870E-02
VA6186       28405       28406 AC   0.00000E+00
LA6186       23984       28405      0.12767E-08
RA6187       28408       24087      0.53870E-02
VA6187       28407       28408 AC   0.00000E+00
LA6187       23987       28407      0.12767E-08
RA6188       28410       24090      0.53870E-02
VA6188       28409       28410 AC   0.00000E+00
LA6188       23990       28409      0.12477E-09
RA6189       28412       24091      0.53870E-02
VA6189       28411       28412 AC   0.00000E+00
LA6189       23991       28411      0.13203E-09
RA6190       28414       24094      0.53870E-02
VA6190       28413       28414 AC   0.00000E+00
LA6190       23994       28413      0.12767E-08
RA6191       28416       24097      0.53870E-02
VA6191       28415       28416 AC   0.00000E+00
LA6191       23997       28415      0.12767E-08
RA6192       28418       24100      0.53870E-02
VA6192       28417       28418 AC   0.00000E+00
LA6192       24000       28417      0.12767E-08
RA6193       28420       24103      0.53870E-02
VA6193       28419       28420 AC   0.00000E+00
LA6193       24003       28419      0.12767E-08
RA6194       28422       24106      0.53870E-02
VA6194       28421       28422 AC   0.00000E+00
LA6194       24006       28421      0.12767E-08
RA6195       28424       24109      0.53870E-02
VA6195       28423       28424 AC   0.00000E+00
LA6195       24009       28423      0.12767E-08
RA6196       28426       24112      0.53870E-02
VA6196       28425       28426 AC   0.00000E+00
LA6196       24012       28425      0.12767E-08
RA6197       28428       24115      0.53870E-02
VA6197       28427       28428 AC   0.00000E+00
LA6197       24015       28427      0.12767E-08
RA6198       28430       24118      0.53870E-02
VA6198       28429       28430 AC   0.00000E+00
LA6198       24018       28429      0.12767E-08
RA6199       28432       24121      0.53870E-02
VA6199       28431       28432 AC   0.00000E+00
LA6199       24021       28431      0.12767E-08
RA6200       28434       24124      0.53870E-02
VA6200       28433       28434 AC   0.00000E+00
LA6200       24024       28433      0.12767E-08
RA6201       28436       24127      0.53870E-02
VA6201       28435       28436 AC   0.00000E+00
LA6201       24027       28435      0.12767E-08
RA6202       28438       24130      0.53870E-02
VA6202       28437       28438 AC   0.00000E+00
LA6202       24030       28437      0.21575E-09
RA6203       28440       24133      0.53870E-02
VA6203       28439       28440 AC   0.00000E+00
LA6203       24033       28439      0.12767E-08
RA6204       28442       24136      0.53870E-02
VA6204       28441       28442 AC   0.00000E+00
LA6204       24036       28441      0.12767E-08
RA6205       28444       24139      0.53870E-02
VA6205       28443       28444 AC   0.00000E+00
LA6205       24039       28443      0.12767E-08
RA6206       28446       24142      0.53870E-02
VA6206       28445       28446 AC   0.00000E+00
LA6206       24042       28445      0.12767E-08
RA6207       28448       24145      0.53870E-02
VA6207       28447       28448 AC   0.00000E+00
LA6207       24045       28447      0.12767E-08
RA6208       28450       24148      0.53870E-02
VA6208       28449       28450 AC   0.00000E+00
LA6208       24048       28449      0.12767E-08
RA6209       28452       24151      0.53870E-02
VA6209       28451       28452 AC   0.00000E+00
LA6209       24051       28451      0.12767E-08
RA6210       28454       24154      0.53870E-02
VA6210       28453       28454 AC   0.00000E+00
LA6210       24054       28453      0.12767E-08
RA6211       28456       24157      0.53870E-02
VA6211       28455       28456 AC   0.00000E+00
LA6211       24057       28455      0.12767E-08
RA6212       28458       24160      0.53870E-02
VA6212       28457       28458 AC   0.00000E+00
LA6212       24060       28457      0.12767E-08
RA6213       28460       24163      0.53870E-02
VA6213       28459       28460 AC   0.00000E+00
LA6213       24063       28459      0.12767E-08
RA6214       28462       24166      0.53870E-02
VA6214       28461       28462 AC   0.00000E+00
LA6214       24066       28461      0.12767E-08
RA6215       28464       24169      0.53870E-02
VA6215       28463       28464 AC   0.00000E+00
LA6215       24069       28463      0.12767E-08
RA6216       28466       24172      0.53870E-02
VA6216       28465       28466 AC   0.00000E+00
LA6216       24072       28465      0.12767E-08
RA6217       28468       24175      0.53870E-02
VA6217       28467       28468 AC   0.00000E+00
LA6217       24075       28467      0.12767E-08
RA6218       28470       24178      0.53870E-02
VA6218       28469       28470 AC   0.00000E+00
LA6218       24078       28469      0.12767E-08
RA6219       28472       24181      0.53870E-02
VA6219       28471       28472 AC   0.00000E+00
LA6219       24081       28471      0.12767E-08
RA6220       28474       24184      0.53870E-02
VA6220       28473       28474 AC   0.00000E+00
LA6220       24084       28473      0.12767E-08
RA6221       28476       24187      0.53870E-02
VA6221       28475       28476 AC   0.00000E+00
LA6221       24087       28475      0.12767E-08
RA6222       28478       24190      0.53870E-02
VA6222       28477       28478 AC   0.00000E+00
LA6222       24090       28477      0.12477E-09
RA6223       28480       24191      0.53870E-02
VA6223       28479       28480 AC   0.00000E+00
LA6223       24091       28479      0.13203E-09
RA6224       28482       24194      0.53870E-02
VA6224       28481       28482 AC   0.00000E+00
LA6224       24094       28481      0.12767E-08
RA6225       28484       24197      0.53870E-02
VA6225       28483       28484 AC   0.00000E+00
LA6225       24097       28483      0.12767E-08
RA6226       28486       24200      0.53870E-02
VA6226       28485       28486 AC   0.00000E+00
LA6226       24100       28485      0.12767E-08
RA6227       28488       24203      0.53870E-02
VA6227       28487       28488 AC   0.00000E+00
LA6227       24103       28487      0.12767E-08
RA6228       28490       24206      0.53870E-02
VA6228       28489       28490 AC   0.00000E+00
LA6228       24106       28489      0.12767E-08
RA6229       28492       24209      0.53870E-02
VA6229       28491       28492 AC   0.00000E+00
LA6229       24109       28491      0.12767E-08
RA6230       28494       24212      0.53870E-02
VA6230       28493       28494 AC   0.00000E+00
LA6230       24112       28493      0.12767E-08
RA6231       28496       24215      0.53870E-02
VA6231       28495       28496 AC   0.00000E+00
LA6231       24115       28495      0.12767E-08
RA6232       28498       24218      0.53870E-02
VA6232       28497       28498 AC   0.00000E+00
LA6232       24118       28497      0.12767E-08
RA6233       28500       24221      0.53870E-02
VA6233       28499       28500 AC   0.00000E+00
LA6233       24121       28499      0.12767E-08
RA6234       28502       24224      0.53870E-02
VA6234       28501       28502 AC   0.00000E+00
LA6234       24124       28501      0.12767E-08
RA6235       28504       24227      0.53870E-02
VA6235       28503       28504 AC   0.00000E+00
LA6235       24127       28503      0.12767E-08
RA6236       28506       24230      0.53870E-02
VA6236       28505       28506 AC   0.00000E+00
LA6236       24130       28505      0.21575E-09
RA6237       28508       24233      0.53870E-02
VA6237       28507       28508 AC   0.00000E+00
LA6237       24133       28507      0.12767E-08
RA6238       28510       24236      0.53870E-02
VA6238       28509       28510 AC   0.00000E+00
LA6238       24136       28509      0.12767E-08
RA6239       28512       24239      0.53870E-02
VA6239       28511       28512 AC   0.00000E+00
LA6239       24139       28511      0.12767E-08
RA6240       28514       24242      0.53870E-02
VA6240       28513       28514 AC   0.00000E+00
LA6240       24142       28513      0.12767E-08
RA6241       28516       24245      0.53870E-02
VA6241       28515       28516 AC   0.00000E+00
LA6241       24145       28515      0.12767E-08
RA6242       28518       24248      0.53870E-02
VA6242       28517       28518 AC   0.00000E+00
LA6242       24148       28517      0.12767E-08
RA6243       28520       24251      0.53870E-02
VA6243       28519       28520 AC   0.00000E+00
LA6243       24151       28519      0.12767E-08
RA6244       28522       24254      0.53870E-02
VA6244       28521       28522 AC   0.00000E+00
LA6244       24154       28521      0.12767E-08
RA6245       28524       24257      0.53870E-02
VA6245       28523       28524 AC   0.00000E+00
LA6245       24157       28523      0.12767E-08
RA6246       28526       24260      0.53870E-02
VA6246       28525       28526 AC   0.00000E+00
LA6246       24160       28525      0.12767E-08
RA6247       28528       24263      0.53870E-02
VA6247       28527       28528 AC   0.00000E+00
LA6247       24163       28527      0.12767E-08
RA6248       28530       24266      0.53870E-02
VA6248       28529       28530 AC   0.00000E+00
LA6248       24166       28529      0.12767E-08
RA6249       28532       24269      0.53870E-02
VA6249       28531       28532 AC   0.00000E+00
LA6249       24169       28531      0.12767E-08
RA6250       28534       24272      0.53870E-02
VA6250       28533       28534 AC   0.00000E+00
LA6250       24172       28533      0.12767E-08
RA6251       28536       24275      0.53870E-02
VA6251       28535       28536 AC   0.00000E+00
LA6251       24175       28535      0.12767E-08
RA6252       28538       24278      0.53870E-02
VA6252       28537       28538 AC   0.00000E+00
LA6252       24178       28537      0.12767E-08
RA6253       28540       24281      0.53870E-02
VA6253       28539       28540 AC   0.00000E+00
LA6253       24181       28539      0.12767E-08
RA6254       28542       24284      0.53870E-02
VA6254       28541       28542 AC   0.00000E+00
LA6254       24184       28541      0.12767E-08
RA6255       28544       24287      0.53870E-02
VA6255       28543       28544 AC   0.00000E+00
LA6255       24187       28543      0.12767E-08
RA6256       28546       24290      0.53870E-02
VA6256       28545       28546 AC   0.00000E+00
LA6256       24190       28545      0.12477E-09
RA6257       28548       24291      0.53870E-02
VA6257       28547       28548 AC   0.00000E+00
LA6257       24191       28547      0.13203E-09
RA6258       28550       24294      0.53870E-02
VA6258       28549       28550 AC   0.00000E+00
LA6258       24194       28549      0.12767E-08
RA6259       28552       24297      0.53870E-02
VA6259       28551       28552 AC   0.00000E+00
LA6259       24197       28551      0.12767E-08
RA6260       28554       24300      0.53870E-02
VA6260       28553       28554 AC   0.00000E+00
LA6260       24200       28553      0.12767E-08
RA6261       28556       24303      0.53870E-02
VA6261       28555       28556 AC   0.00000E+00
LA6261       24203       28555      0.12767E-08
RA6262       28558       24306      0.53870E-02
VA6262       28557       28558 AC   0.00000E+00
LA6262       24206       28557      0.12767E-08
RA6263       28560       24309      0.53870E-02
VA6263       28559       28560 AC   0.00000E+00
LA6263       24209       28559      0.12767E-08
RA6264       28562       24312      0.53870E-02
VA6264       28561       28562 AC   0.00000E+00
LA6264       24212       28561      0.12767E-08
RA6265       28564       24315      0.53870E-02
VA6265       28563       28564 AC   0.00000E+00
LA6265       24215       28563      0.12767E-08
RA6266       28566       24318      0.53870E-02
VA6266       28565       28566 AC   0.00000E+00
LA6266       24218       28565      0.12767E-08
RA6267       28568       24321      0.53870E-02
VA6267       28567       28568 AC   0.00000E+00
LA6267       24221       28567      0.12767E-08
RA6268       28570       24324      0.53870E-02
VA6268       28569       28570 AC   0.00000E+00
LA6268       24224       28569      0.12767E-08
RA6269       28572       24327      0.53870E-02
VA6269       28571       28572 AC   0.00000E+00
LA6269       24227       28571      0.12767E-08
RA6270       28574       24330      0.53870E-02
VA6270       28573       28574 AC   0.00000E+00
LA6270       24230       28573      0.21575E-09
RA6271       28576       24333      0.53870E-02
VA6271       28575       28576 AC   0.00000E+00
LA6271       24233       28575      0.12767E-08
RA6272       28578       24336      0.53870E-02
VA6272       28577       28578 AC   0.00000E+00
LA6272       24236       28577      0.12767E-08
RA6273       28580       24339      0.53870E-02
VA6273       28579       28580 AC   0.00000E+00
LA6273       24239       28579      0.12767E-08
RA6274       28582       24342      0.53870E-02
VA6274       28581       28582 AC   0.00000E+00
LA6274       24242       28581      0.12767E-08
RA6275       28584       24345      0.53870E-02
VA6275       28583       28584 AC   0.00000E+00
LA6275       24245       28583      0.12767E-08
RA6276       28586       24348      0.53870E-02
VA6276       28585       28586 AC   0.00000E+00
LA6276       24248       28585      0.12767E-08
RA6277       28588       24351      0.53870E-02
VA6277       28587       28588 AC   0.00000E+00
LA6277       24251       28587      0.12767E-08
RA6278       28590       24354      0.53870E-02
VA6278       28589       28590 AC   0.00000E+00
LA6278       24254       28589      0.12767E-08
RA6279       28592       24357      0.53870E-02
VA6279       28591       28592 AC   0.00000E+00
LA6279       24257       28591      0.12767E-08
RA6280       28594       24360      0.53870E-02
VA6280       28593       28594 AC   0.00000E+00
LA6280       24260       28593      0.12767E-08
RA6281       28596       24363      0.53870E-02
VA6281       28595       28596 AC   0.00000E+00
LA6281       24263       28595      0.12767E-08
RA6282       28598       24366      0.53870E-02
VA6282       28597       28598 AC   0.00000E+00
LA6282       24266       28597      0.12767E-08
RA6283       28600       24369      0.53870E-02
VA6283       28599       28600 AC   0.00000E+00
LA6283       24269       28599      0.12767E-08
RA6284       28602       24372      0.53870E-02
VA6284       28601       28602 AC   0.00000E+00
LA6284       24272       28601      0.12767E-08
RA6285       28604       24375      0.53870E-02
VA6285       28603       28604 AC   0.00000E+00
LA6285       24275       28603      0.12767E-08
RA6286       28606       24378      0.53870E-02
VA6286       28605       28606 AC   0.00000E+00
LA6286       24278       28605      0.12767E-08
RA6287       28608       24381      0.53870E-02
VA6287       28607       28608 AC   0.00000E+00
LA6287       24281       28607      0.12767E-08
RA6288       28610       24384      0.53870E-02
VA6288       28609       28610 AC   0.00000E+00
LA6288       24284       28609      0.12767E-08
RA6289       28612       24387      0.53870E-02
VA6289       28611       28612 AC   0.00000E+00
LA6289       24287       28611      0.12767E-08
RA6290       28614       24390      0.53870E-02
VA6290       28613       28614 AC   0.00000E+00
LA6290       24290       28613      0.12477E-09
RA6291       28616       24391      0.53870E-02
VA6291       28615       28616 AC   0.00000E+00
LA6291       24291       28615      0.13203E-09
RA6292       28618       24394      0.53870E-02
VA6292       28617       28618 AC   0.00000E+00
LA6292       24294       28617      0.12767E-08
RA6293       28620       24397      0.53870E-02
VA6293       28619       28620 AC   0.00000E+00
LA6293       24297       28619      0.12767E-08
RA6294       28622       24400      0.53870E-02
VA6294       28621       28622 AC   0.00000E+00
LA6294       24300       28621      0.12767E-08
RA6295       28624       24403      0.53870E-02
VA6295       28623       28624 AC   0.00000E+00
LA6295       24303       28623      0.12767E-08
RA6296       28626       24406      0.53870E-02
VA6296       28625       28626 AC   0.00000E+00
LA6296       24306       28625      0.12767E-08
RA6297       28628       24409      0.53870E-02
VA6297       28627       28628 AC   0.00000E+00
LA6297       24309       28627      0.12767E-08
RA6298       28630       24412      0.53870E-02
VA6298       28629       28630 AC   0.00000E+00
LA6298       24312       28629      0.12767E-08
RA6299       28632       24415      0.53870E-02
VA6299       28631       28632 AC   0.00000E+00
LA6299       24315       28631      0.12767E-08
RA6300       28634       24418      0.53870E-02
VA6300       28633       28634 AC   0.00000E+00
LA6300       24318       28633      0.12767E-08
RA6301       28636       24421      0.53870E-02
VA6301       28635       28636 AC   0.00000E+00
LA6301       24321       28635      0.12767E-08
RA6302       28638       24424      0.53870E-02
VA6302       28637       28638 AC   0.00000E+00
LA6302       24324       28637      0.12767E-08
RA6303       28640       24427      0.53870E-02
VA6303       28639       28640 AC   0.00000E+00
LA6303       24327       28639      0.12767E-08
RA6304       28642       24430      0.53870E-02
VA6304       28641       28642 AC   0.00000E+00
LA6304       24330       28641      0.21575E-09
RA6305       28644       24433      0.53870E-02
VA6305       28643       28644 AC   0.00000E+00
LA6305       24333       28643      0.12767E-08
RA6306       28646       24436      0.53870E-02
VA6306       28645       28646 AC   0.00000E+00
LA6306       24336       28645      0.12767E-08
RA6307       28648       24439      0.53870E-02
VA6307       28647       28648 AC   0.00000E+00
LA6307       24339       28647      0.12767E-08
RA6308       28650       24442      0.53870E-02
VA6308       28649       28650 AC   0.00000E+00
LA6308       24342       28649      0.12767E-08
RA6309       28652       24445      0.53870E-02
VA6309       28651       28652 AC   0.00000E+00
LA6309       24345       28651      0.12767E-08
RA6310       28654       24448      0.53870E-02
VA6310       28653       28654 AC   0.00000E+00
LA6310       24348       28653      0.12767E-08
RA6311       28656       24451      0.53870E-02
VA6311       28655       28656 AC   0.00000E+00
LA6311       24351       28655      0.12767E-08
RA6312       28658       24454      0.53870E-02
VA6312       28657       28658 AC   0.00000E+00
LA6312       24354       28657      0.12767E-08
RA6313       28660       24457      0.53870E-02
VA6313       28659       28660 AC   0.00000E+00
LA6313       24357       28659      0.12767E-08
RA6314       28662       24460      0.53870E-02
VA6314       28661       28662 AC   0.00000E+00
LA6314       24360       28661      0.12767E-08
RA6315       28664       24463      0.53870E-02
VA6315       28663       28664 AC   0.00000E+00
LA6315       24363       28663      0.12767E-08
RA6316       28666       24466      0.53870E-02
VA6316       28665       28666 AC   0.00000E+00
LA6316       24366       28665      0.12767E-08
RA6317       28668       24469      0.53870E-02
VA6317       28667       28668 AC   0.00000E+00
LA6317       24369       28667      0.12767E-08
RA6318       28670       24472      0.53870E-02
VA6318       28669       28670 AC   0.00000E+00
LA6318       24372       28669      0.12767E-08
RA6319       28672       24475      0.53870E-02
VA6319       28671       28672 AC   0.00000E+00
LA6319       24375       28671      0.12767E-08
RA6320       28674       24478      0.53870E-02
VA6320       28673       28674 AC   0.00000E+00
LA6320       24378       28673      0.12767E-08
RA6321       28676       24481      0.53870E-02
VA6321       28675       28676 AC   0.00000E+00
LA6321       24381       28675      0.12767E-08
RA6322       28678       24484      0.53870E-02
VA6322       28677       28678 AC   0.00000E+00
LA6322       24384       28677      0.12767E-08
RA6323       28680       24487      0.53870E-02
VA6323       28679       28680 AC   0.00000E+00
LA6323       24387       28679      0.12767E-08
RA6324       28682       24490      0.53870E-02
VA6324       28681       28682 AC   0.00000E+00
LA6324       24390       28681      0.12477E-09
RA6325       28684       24491      0.53870E-02
VA6325       28683       28684 AC   0.00000E+00
LA6325       24391       28683      0.13203E-09
RA6326       28686       24494      0.53870E-02
VA6326       28685       28686 AC   0.00000E+00
LA6326       24394       28685      0.12767E-08
RA6327       28688       24497      0.53870E-02
VA6327       28687       28688 AC   0.00000E+00
LA6327       24397       28687      0.12767E-08
RA6328       28690       24500      0.53870E-02
VA6328       28689       28690 AC   0.00000E+00
LA6328       24400       28689      0.12767E-08
RA6329       28692       24503      0.53870E-02
VA6329       28691       28692 AC   0.00000E+00
LA6329       24403       28691      0.12767E-08
RA6330       28694       24506      0.53870E-02
VA6330       28693       28694 AC   0.00000E+00
LA6330       24406       28693      0.12767E-08
RA6331       28696       24509      0.53870E-02
VA6331       28695       28696 AC   0.00000E+00
LA6331       24409       28695      0.12767E-08
RA6332       28698       24512      0.53870E-02
VA6332       28697       28698 AC   0.00000E+00
LA6332       24412       28697      0.12767E-08
RA6333       28700       24515      0.53870E-02
VA6333       28699       28700 AC   0.00000E+00
LA6333       24415       28699      0.12767E-08
RA6334       28702       24518      0.53870E-02
VA6334       28701       28702 AC   0.00000E+00
LA6334       24418       28701      0.12767E-08
RA6335       28704       24521      0.53870E-02
VA6335       28703       28704 AC   0.00000E+00
LA6335       24421       28703      0.12767E-08
RA6336       28706       24524      0.53870E-02
VA6336       28705       28706 AC   0.00000E+00
LA6336       24424       28705      0.12767E-08
RA6337       28708       24527      0.53870E-02
VA6337       28707       28708 AC   0.00000E+00
LA6337       24427       28707      0.12767E-08
RA6338       28710       24530      0.53870E-02
VA6338       28709       28710 AC   0.00000E+00
LA6338       24430       28709      0.21575E-09
RA6339       28712       24533      0.53870E-02
VA6339       28711       28712 AC   0.00000E+00
LA6339       24433       28711      0.12767E-08
RA6340       28714       24536      0.53870E-02
VA6340       28713       28714 AC   0.00000E+00
LA6340       24436       28713      0.12767E-08
RA6341       28716       24539      0.53870E-02
VA6341       28715       28716 AC   0.00000E+00
LA6341       24439       28715      0.12767E-08
RA6342       28718       24542      0.53870E-02
VA6342       28717       28718 AC   0.00000E+00
LA6342       24442       28717      0.12767E-08
RA6343       28720       24545      0.53870E-02
VA6343       28719       28720 AC   0.00000E+00
LA6343       24445       28719      0.12767E-08
RA6344       28722       24548      0.53870E-02
VA6344       28721       28722 AC   0.00000E+00
LA6344       24448       28721      0.12767E-08
RA6345       28724       24551      0.53870E-02
VA6345       28723       28724 AC   0.00000E+00
LA6345       24451       28723      0.12767E-08
RA6346       28726       24554      0.53870E-02
VA6346       28725       28726 AC   0.00000E+00
LA6346       24454       28725      0.12767E-08
RA6347       28728       24557      0.53870E-02
VA6347       28727       28728 AC   0.00000E+00
LA6347       24457       28727      0.12767E-08
RA6348       28730       24560      0.53870E-02
VA6348       28729       28730 AC   0.00000E+00
LA6348       24460       28729      0.12767E-08
RA6349       28732       24563      0.53870E-02
VA6349       28731       28732 AC   0.00000E+00
LA6349       24463       28731      0.12767E-08
RA6350       28734       24566      0.53870E-02
VA6350       28733       28734 AC   0.00000E+00
LA6350       24466       28733      0.12767E-08
RA6351       28736       24569      0.53870E-02
VA6351       28735       28736 AC   0.00000E+00
LA6351       24469       28735      0.12767E-08
RA6352       28738       24572      0.53870E-02
VA6352       28737       28738 AC   0.00000E+00
LA6352       24472       28737      0.12767E-08
RA6353       28740       24575      0.53870E-02
VA6353       28739       28740 AC   0.00000E+00
LA6353       24475       28739      0.12767E-08
RA6354       28742       24578      0.53870E-02
VA6354       28741       28742 AC   0.00000E+00
LA6354       24478       28741      0.12767E-08
RA6355       28744       24581      0.53870E-02
VA6355       28743       28744 AC   0.00000E+00
LA6355       24481       28743      0.12767E-08
RA6356       28746       24584      0.53870E-02
VA6356       28745       28746 AC   0.00000E+00
LA6356       24484       28745      0.12767E-08
RA6357       28748       24587      0.53870E-02
VA6357       28747       28748 AC   0.00000E+00
LA6357       24487       28747      0.12767E-08
RA6358       28750       24590      0.53870E-02
VA6358       28749       28750 AC   0.00000E+00
LA6358       24490       28749      0.12477E-09
RA6359       28752       24591      0.53870E-02
VA6359       28751       28752 AC   0.00000E+00
LA6359       24491       28751      0.13203E-09
RA6360       28754       24594      0.53870E-02
VA6360       28753       28754 AC   0.00000E+00
LA6360       24494       28753      0.12767E-08
RA6361       28756       24597      0.53870E-02
VA6361       28755       28756 AC   0.00000E+00
LA6361       24497       28755      0.12767E-08
RA6362       28758       24600      0.53870E-02
VA6362       28757       28758 AC   0.00000E+00
LA6362       24500       28757      0.12767E-08
RA6363       28760       24603      0.53870E-02
VA6363       28759       28760 AC   0.00000E+00
LA6363       24503       28759      0.12767E-08
RA6364       28762       24606      0.53870E-02
VA6364       28761       28762 AC   0.00000E+00
LA6364       24506       28761      0.12767E-08
RA6365       28764       24609      0.53870E-02
VA6365       28763       28764 AC   0.00000E+00
LA6365       24509       28763      0.12767E-08
RA6366       28766       24612      0.53870E-02
VA6366       28765       28766 AC   0.00000E+00
LA6366       24512       28765      0.12767E-08
RA6367       28768       24615      0.53870E-02
VA6367       28767       28768 AC   0.00000E+00
LA6367       24515       28767      0.12767E-08
RA6368       28770       24618      0.53870E-02
VA6368       28769       28770 AC   0.00000E+00
LA6368       24518       28769      0.12767E-08
RA6369       28772       24621      0.53870E-02
VA6369       28771       28772 AC   0.00000E+00
LA6369       24521       28771      0.12767E-08
RA6370       28774       24624      0.53870E-02
VA6370       28773       28774 AC   0.00000E+00
LA6370       24524       28773      0.12767E-08
RA6371       28776       24627      0.53870E-02
VA6371       28775       28776 AC   0.00000E+00
LA6371       24527       28775      0.12767E-08
RA6372       28778       24630      0.53870E-02
VA6372       28777       28778 AC   0.00000E+00
LA6372       24530       28777      0.21575E-09
RA6373       28780       24633      0.53870E-02
VA6373       28779       28780 AC   0.00000E+00
LA6373       24533       28779      0.12767E-08
RA6374       28782       24636      0.53870E-02
VA6374       28781       28782 AC   0.00000E+00
LA6374       24536       28781      0.12767E-08
RA6375       28784       24639      0.53870E-02
VA6375       28783       28784 AC   0.00000E+00
LA6375       24539       28783      0.12767E-08
RA6376       28786       24642      0.53870E-02
VA6376       28785       28786 AC   0.00000E+00
LA6376       24542       28785      0.12767E-08
RA6377       28788       24645      0.53870E-02
VA6377       28787       28788 AC   0.00000E+00
LA6377       24545       28787      0.12767E-08
RA6378       28790       24648      0.53870E-02
VA6378       28789       28790 AC   0.00000E+00
LA6378       24548       28789      0.12767E-08
RA6379       28792       24651      0.53870E-02
VA6379       28791       28792 AC   0.00000E+00
LA6379       24551       28791      0.12767E-08
RA6380       28794       24654      0.53870E-02
VA6380       28793       28794 AC   0.00000E+00
LA6380       24554       28793      0.12767E-08
RA6381       28796       24657      0.53870E-02
VA6381       28795       28796 AC   0.00000E+00
LA6381       24557       28795      0.12767E-08
RA6382       28798       24660      0.53870E-02
VA6382       28797       28798 AC   0.00000E+00
LA6382       24560       28797      0.12767E-08
RA6383       28800       24663      0.53870E-02
VA6383       28799       28800 AC   0.00000E+00
LA6383       24563       28799      0.12767E-08
RA6384       28802       24666      0.53870E-02
VA6384       28801       28802 AC   0.00000E+00
LA6384       24566       28801      0.12767E-08
RA6385       28804       24669      0.53870E-02
VA6385       28803       28804 AC   0.00000E+00
LA6385       24569       28803      0.12767E-08
RA6386       28806       24672      0.53870E-02
VA6386       28805       28806 AC   0.00000E+00
LA6386       24572       28805      0.12767E-08
RA6387       28808       24675      0.53870E-02
VA6387       28807       28808 AC   0.00000E+00
LA6387       24575       28807      0.12767E-08
RA6388       28810       24678      0.53870E-02
VA6388       28809       28810 AC   0.00000E+00
LA6388       24578       28809      0.12767E-08
RA6389       28812       24681      0.53870E-02
VA6389       28811       28812 AC   0.00000E+00
LA6389       24581       28811      0.12767E-08
RA6390       28814       24684      0.53870E-02
VA6390       28813       28814 AC   0.00000E+00
LA6390       24584       28813      0.12767E-08
RA6391       28816       24687      0.53870E-02
VA6391       28815       28816 AC   0.00000E+00
LA6391       24587       28815      0.12767E-08
RA6392       28818       24690      0.53870E-02
VA6392       28817       28818 AC   0.00000E+00
LA6392       24590       28817      0.70074E-09
RA6393       28820       24729      0.53870E-02
VA6393       28819       28820 AC   0.00000E+00
LA6393       24591       28819      0.70437E-09
RA6394       28822       24732      0.53870E-02
VA6394       28821       28822 AC   0.00000E+00
LA6394       24594       28821      0.12767E-08
RA6395       28824       24735      0.53870E-02
VA6395       28823       28824 AC   0.00000E+00
LA6395       24597       28823      0.12767E-08
RA6396       28826       24738      0.53870E-02
VA6396       28825       28826 AC   0.00000E+00
LA6396       24600       28825      0.12767E-08
RA6397       28828       24741      0.53870E-02
VA6397       28827       28828 AC   0.00000E+00
LA6397       24603       28827      0.12767E-08
RA6398       28830       24744      0.53870E-02
VA6398       28829       28830 AC   0.00000E+00
LA6398       24606       28829      0.12767E-08
RA6399       28832       24747      0.53870E-02
VA6399       28831       28832 AC   0.00000E+00
LA6399       24609       28831      0.12767E-08
RA6400       28834       24750      0.53870E-02
VA6400       28833       28834 AC   0.00000E+00
LA6400       24612       28833      0.12767E-08
RA6401       28836       24753      0.53870E-02
VA6401       28835       28836 AC   0.00000E+00
LA6401       24615       28835      0.12767E-08
RA6402       28838       24756      0.53870E-02
VA6402       28837       28838 AC   0.00000E+00
LA6402       24618       28837      0.12767E-08
RA6403       28840       24759      0.53870E-02
VA6403       28839       28840 AC   0.00000E+00
LA6403       24621       28839      0.12767E-08
RA6404       28842       24762      0.53870E-02
VA6404       28841       28842 AC   0.00000E+00
LA6404       24624       28841      0.12767E-08
RA6405       28844       24765      0.53870E-02
VA6405       28843       28844 AC   0.00000E+00
LA6405       24627       28843      0.12767E-08
RA6406       28846       24768      0.53870E-02
VA6406       28845       28846 AC   0.00000E+00
LA6406       24630       28845      0.19652E-09
RA6407       28848       24771      0.53870E-02
VA6407       28847       28848 AC   0.00000E+00
LA6407       24633       28847      0.12767E-08
RA6408       28850       24774      0.53870E-02
VA6408       28849       28850 AC   0.00000E+00
LA6408       24636       28849      0.12767E-08
RA6409       28852       24777      0.53870E-02
VA6409       28851       28852 AC   0.00000E+00
LA6409       24639       28851      0.12767E-08
RA6410       28854       24780      0.53870E-02
VA6410       28853       28854 AC   0.00000E+00
LA6410       24642       28853      0.12767E-08
RA6411       28856       24783      0.53870E-02
VA6411       28855       28856 AC   0.00000E+00
LA6411       24645       28855      0.12767E-08
RA6412       28858       24786      0.53870E-02
VA6412       28857       28858 AC   0.00000E+00
LA6412       24648       28857      0.12767E-08
RA6413       28860       24789      0.53870E-02
VA6413       28859       28860 AC   0.00000E+00
LA6413       24651       28859      0.12767E-08
RA6414       28862       24792      0.53870E-02
VA6414       28861       28862 AC   0.00000E+00
LA6414       24654       28861      0.12767E-08
RA6415       28864       24795      0.53870E-02
VA6415       28863       28864 AC   0.00000E+00
LA6415       24657       28863      0.12767E-08
RA6416       28866       24798      0.53870E-02
VA6416       28865       28866 AC   0.00000E+00
LA6416       24660       28865      0.12767E-08
RA6417       28868       24801      0.53870E-02
VA6417       28867       28868 AC   0.00000E+00
LA6417       24663       28867      0.12767E-08
RA6418       28870       24804      0.53870E-02
VA6418       28869       28870 AC   0.00000E+00
LA6418       24666       28869      0.12767E-08
RA6419       28872       24807      0.53870E-02
VA6419       28871       28872 AC   0.00000E+00
LA6419       24669       28871      0.12767E-08
RA6420       28874       24810      0.53870E-02
VA6420       28873       28874 AC   0.00000E+00
LA6420       24672       28873      0.12767E-08
RA6421       28876       24813      0.53870E-02
VA6421       28875       28876 AC   0.00000E+00
LA6421       24675       28875      0.12767E-08
RA6422       28878       24816      0.53870E-02
VA6422       28877       28878 AC   0.00000E+00
LA6422       24678       28877      0.12767E-08
RA6423       28880       24819      0.53870E-02
VA6423       28879       28880 AC   0.00000E+00
LA6423       24681       28879      0.12767E-08
RA6424       28882       24822      0.53870E-02
VA6424       28881       28882 AC   0.00000E+00
LA6424       24684       28881      0.12767E-08
RA6425       28884       24825      0.53870E-02
VA6425       28883       28884 AC   0.00000E+00
LA6425       24687       28883      0.12767E-08
RA6426       28886       24828      0.53870E-02
VA6426       28885       28886 AC   0.00000E+00
LA6426       24690       28885      0.12767E-08
RA6427       28888       24831      0.53870E-02
VA6427       28887       28888 AC   0.00000E+00
LA6427       24693       28887      0.12767E-08
RA6428       28890       24834      0.53870E-02
VA6428       28889       28890 AC   0.00000E+00
LA6428       24696       28889      0.12767E-08
RA6429       28892       24837      0.53870E-02
VA6429       28891       28892 AC   0.00000E+00
LA6429       24699       28891      0.12767E-08
RA6430       28894       24840      0.53870E-02
VA6430       28893       28894 AC   0.00000E+00
LA6430       24702       28893      0.12767E-08
RA6431       28896       24843      0.53870E-02
VA6431       28895       28896 AC   0.00000E+00
LA6431       24705       28895      0.12767E-08
RA6432       28898       24846      0.53870E-02
VA6432       28897       28898 AC   0.00000E+00
LA6432       24708       28897      0.12767E-08
RA6433       28900       24849      0.53870E-02
VA6433       28899       28900 AC   0.00000E+00
LA6433       24711       28899      0.12767E-08
RA6434       28902       24852      0.53870E-02
VA6434       28901       28902 AC   0.00000E+00
LA6434       24714       28901      0.12767E-08
RA6435       28904       24855      0.53870E-02
VA6435       28903       28904 AC   0.00000E+00
LA6435       24717       28903      0.12767E-08
RA6436       28906       24858      0.53870E-02
VA6436       28905       28906 AC   0.00000E+00
LA6436       24720       28905      0.12767E-08
RA6437       28908       24861      0.53870E-02
VA6437       28907       28908 AC   0.00000E+00
LA6437       24723       28907      0.12767E-08
RA6438       28910       24864      0.53870E-02
VA6438       28909       28910 AC   0.00000E+00
LA6438       24726       28909      0.12767E-08
RA6439       28912       24867      0.53870E-02
VA6439       28911       28912 AC   0.00000E+00
LA6439       24729       28911      0.12767E-08
RA6440       28914       24870      0.53870E-02
VA6440       28913       28914 AC   0.00000E+00
LA6440       24732       28913      0.12767E-08
RA6441       28916       24873      0.53870E-02
VA6441       28915       28916 AC   0.00000E+00
LA6441       24735       28915      0.12767E-08
RA6442       28918       24876      0.53870E-02
VA6442       28917       28918 AC   0.00000E+00
LA6442       24738       28917      0.12767E-08
RA6443       28920       24879      0.53870E-02
VA6443       28919       28920 AC   0.00000E+00
LA6443       24741       28919      0.12767E-08
RA6444       28922       24882      0.53870E-02
VA6444       28921       28922 AC   0.00000E+00
LA6444       24744       28921      0.12767E-08
RA6445       28924       24885      0.53870E-02
VA6445       28923       28924 AC   0.00000E+00
LA6445       24747       28923      0.12767E-08
RA6446       28926       24888      0.53870E-02
VA6446       28925       28926 AC   0.00000E+00
LA6446       24750       28925      0.12767E-08
RA6447       28928       24891      0.53870E-02
VA6447       28927       28928 AC   0.00000E+00
LA6447       24753       28927      0.12767E-08
RA6448       28930       24894      0.53870E-02
VA6448       28929       28930 AC   0.00000E+00
LA6448       24756       28929      0.12767E-08
RA6449       28932       24897      0.53870E-02
VA6449       28931       28932 AC   0.00000E+00
LA6449       24759       28931      0.12767E-08
RA6450       28934       24900      0.53870E-02
VA6450       28933       28934 AC   0.00000E+00
LA6450       24762       28933      0.12767E-08
RA6451       28936       24903      0.53870E-02
VA6451       28935       28936 AC   0.00000E+00
LA6451       24765       28935      0.12767E-08
RA6452       28938       24906      0.53870E-02
VA6452       28937       28938 AC   0.00000E+00
LA6452       24768       28937      0.17730E-09
RA6453       28940       24909      0.53870E-02
VA6453       28939       28940 AC   0.00000E+00
LA6453       24771       28939      0.12767E-08
RA6454       28942       24912      0.53870E-02
VA6454       28941       28942 AC   0.00000E+00
LA6454       24774       28941      0.12767E-08
RA6455       28944       24915      0.53870E-02
VA6455       28943       28944 AC   0.00000E+00
LA6455       24777       28943      0.12767E-08
RA6456       28946       24918      0.53870E-02
VA6456       28945       28946 AC   0.00000E+00
LA6456       24780       28945      0.12767E-08
RA6457       28948       24921      0.53870E-02
VA6457       28947       28948 AC   0.00000E+00
LA6457       24783       28947      0.12767E-08
RA6458       28950       24924      0.53870E-02
VA6458       28949       28950 AC   0.00000E+00
LA6458       24786       28949      0.12767E-08
RA6459       28952       24927      0.53870E-02
VA6459       28951       28952 AC   0.00000E+00
LA6459       24789       28951      0.12767E-08
RA6460       28954       24930      0.53870E-02
VA6460       28953       28954 AC   0.00000E+00
LA6460       24792       28953      0.12767E-08
RA6461       28956       24933      0.53870E-02
VA6461       28955       28956 AC   0.00000E+00
LA6461       24795       28955      0.12767E-08
RA6462       28958       24936      0.53870E-02
VA6462       28957       28958 AC   0.00000E+00
LA6462       24798       28957      0.12767E-08
RA6463       28960       24939      0.53870E-02
VA6463       28959       28960 AC   0.00000E+00
LA6463       24801       28959      0.12767E-08
RA6464       28962       24942      0.53870E-02
VA6464       28961       28962 AC   0.00000E+00
LA6464       24804       28961      0.12767E-08
RA6465       28964       24945      0.53870E-02
VA6465       28963       28964 AC   0.00000E+00
LA6465       24807       28963      0.12767E-08
RA6466       28966       24948      0.53870E-02
VA6466       28965       28966 AC   0.00000E+00
LA6466       24810       28965      0.12767E-08
RA6467       28968       24951      0.53870E-02
VA6467       28967       28968 AC   0.00000E+00
LA6467       24813       28967      0.12767E-08
RA6468       28970       24954      0.53870E-02
VA6468       28969       28970 AC   0.00000E+00
LA6468       24816       28969      0.12767E-08
RA6469       28972       24957      0.53870E-02
VA6469       28971       28972 AC   0.00000E+00
LA6469       24819       28971      0.12767E-08
RA6470       28974       24960      0.53870E-02
VA6470       28973       28974 AC   0.00000E+00
LA6470       24822       28973      0.12767E-08
RA6471       28976       24963      0.53870E-02
VA6471       28975       28976 AC   0.00000E+00
LA6471       24825       28975      0.12767E-08
RA6472       28978       24966      0.53870E-02
VA6472       28977       28978 AC   0.00000E+00
LA6472       24828       28977      0.12767E-08
RA6473       28980       24969      0.53870E-02
VA6473       28979       28980 AC   0.00000E+00
LA6473       24831       28979      0.12767E-08
RA6474       28982       24972      0.53870E-02
VA6474       28981       28982 AC   0.00000E+00
LA6474       24834       28981      0.12767E-08
RA6475       28984       24975      0.53870E-02
VA6475       28983       28984 AC   0.00000E+00
LA6475       24837       28983      0.12767E-08
RA6476       28986       24978      0.53870E-02
VA6476       28985       28986 AC   0.00000E+00
LA6476       24840       28985      0.12767E-08
RA6477       28988       24981      0.53870E-02
VA6477       28987       28988 AC   0.00000E+00
LA6477       24843       28987      0.12767E-08
RA6478       28990       24984      0.53870E-02
VA6478       28989       28990 AC   0.00000E+00
LA6478       24846       28989      0.12767E-08
RA6479       28992       24987      0.53870E-02
VA6479       28991       28992 AC   0.00000E+00
LA6479       24849       28991      0.12767E-08
RA6480       28994       24990      0.53870E-02
VA6480       28993       28994 AC   0.00000E+00
LA6480       24852       28993      0.12767E-08
RA6481       28996       24993      0.53870E-02
VA6481       28995       28996 AC   0.00000E+00
LA6481       24855       28995      0.12767E-08
RA6482       28998       24996      0.53870E-02
VA6482       28997       28998 AC   0.00000E+00
LA6482       24858       28997      0.12767E-08
RA6483       29000       24999      0.53870E-02
VA6483       28999       29000 AC   0.00000E+00
LA6483       24861       28999      0.12767E-08
RA6484       29002       25002      0.53870E-02
VA6484       29001       29002 AC   0.00000E+00
LA6484       24864       29001      0.12767E-08
RA6485       29004       25005      0.53870E-02
VA6485       29003       29004 AC   0.00000E+00
LA6485       24867       29003      0.12767E-08
RA6486       29006       25008      0.53870E-02
VA6486       29005       29006 AC   0.00000E+00
LA6486       24870       29005      0.12767E-08
RA6487       29008       25011      0.53870E-02
VA6487       29007       29008 AC   0.00000E+00
LA6487       24873       29007      0.12767E-08
RA6488       29010       25014      0.53870E-02
VA6488       29009       29010 AC   0.00000E+00
LA6488       24876       29009      0.12767E-08
RA6489       29012       25017      0.53870E-02
VA6489       29011       29012 AC   0.00000E+00
LA6489       24879       29011      0.12767E-08
RA6490       29014       25020      0.53870E-02
VA6490       29013       29014 AC   0.00000E+00
LA6490       24882       29013      0.12767E-08
RA6491       29016       25023      0.53870E-02
VA6491       29015       29016 AC   0.00000E+00
LA6491       24885       29015      0.12767E-08
RA6492       29018       25026      0.53870E-02
VA6492       29017       29018 AC   0.00000E+00
LA6492       24888       29017      0.12767E-08
RA6493       29020       25029      0.53870E-02
VA6493       29019       29020 AC   0.00000E+00
LA6493       24891       29019      0.12767E-08
RA6494       29022       25032      0.53870E-02
VA6494       29021       29022 AC   0.00000E+00
LA6494       24894       29021      0.12767E-08
RA6495       29024       25035      0.53870E-02
VA6495       29023       29024 AC   0.00000E+00
LA6495       24897       29023      0.12767E-08
RA6496       29026       25038      0.53870E-02
VA6496       29025       29026 AC   0.00000E+00
LA6496       24900       29025      0.12767E-08
RA6497       29028       25041      0.53870E-02
VA6497       29027       29028 AC   0.00000E+00
LA6497       24903       29027      0.12767E-08
RA6498       29030       25044      0.53870E-02
VA6498       29029       29030 AC   0.00000E+00
LA6498       24906       29029      0.17730E-09
RA6499       29032       25047      0.53870E-02
VA6499       29031       29032 AC   0.00000E+00
LA6499       24909       29031      0.12767E-08
RA6500       29034       25050      0.53870E-02
VA6500       29033       29034 AC   0.00000E+00
LA6500       24912       29033      0.12767E-08
RA6501       29036       25053      0.53870E-02
VA6501       29035       29036 AC   0.00000E+00
LA6501       24915       29035      0.12767E-08
RA6502       29038       25056      0.53870E-02
VA6502       29037       29038 AC   0.00000E+00
LA6502       24918       29037      0.12767E-08
RA6503       29040       25059      0.53870E-02
VA6503       29039       29040 AC   0.00000E+00
LA6503       24921       29039      0.12767E-08
RA6504       29042       25062      0.53870E-02
VA6504       29041       29042 AC   0.00000E+00
LA6504       24924       29041      0.12767E-08
RA6505       29044       25065      0.53870E-02
VA6505       29043       29044 AC   0.00000E+00
LA6505       24927       29043      0.12767E-08
RA6506       29046       25068      0.53870E-02
VA6506       29045       29046 AC   0.00000E+00
LA6506       24930       29045      0.12767E-08
RA6507       29048       25071      0.53870E-02
VA6507       29047       29048 AC   0.00000E+00
LA6507       24933       29047      0.12767E-08
RA6508       29050       25074      0.53870E-02
VA6508       29049       29050 AC   0.00000E+00
LA6508       24936       29049      0.12767E-08
RA6509       29052       25077      0.53870E-02
VA6509       29051       29052 AC   0.00000E+00
LA6509       24939       29051      0.12767E-08
RA6510       29054       25080      0.53870E-02
VA6510       29053       29054 AC   0.00000E+00
LA6510       24942       29053      0.12767E-08
RA6511       29056       25083      0.53870E-02
VA6511       29055       29056 AC   0.00000E+00
LA6511       24945       29055      0.12767E-08
RA6512       29058       25086      0.53870E-02
VA6512       29057       29058 AC   0.00000E+00
LA6512       24948       29057      0.12767E-08
RA6513       29060       25089      0.53870E-02
VA6513       29059       29060 AC   0.00000E+00
LA6513       24951       29059      0.12767E-08
RA6514       29062       25092      0.53870E-02
VA6514       29061       29062 AC   0.00000E+00
LA6514       24954       29061      0.12767E-08
RA6515       29064       25095      0.53870E-02
VA6515       29063       29064 AC   0.00000E+00
LA6515       24957       29063      0.12767E-08
RA6516       29066       25098      0.53870E-02
VA6516       29065       29066 AC   0.00000E+00
LA6516       24960       29065      0.12767E-08
RA6517       29068       25101      0.53870E-02
VA6517       29067       29068 AC   0.00000E+00
LA6517       24963       29067      0.12767E-08
RA6518       29070       25104      0.53870E-02
VA6518       29069       29070 AC   0.00000E+00
LA6518       24966       29069      0.12767E-08
RA6519       29072       25107      0.53870E-02
VA6519       29071       29072 AC   0.00000E+00
LA6519       24969       29071      0.12767E-08
RA6520       29074       25110      0.53870E-02
VA6520       29073       29074 AC   0.00000E+00
LA6520       24972       29073      0.12767E-08
RA6521       29076       25113      0.53870E-02
VA6521       29075       29076 AC   0.00000E+00
LA6521       24975       29075      0.12767E-08
RA6522       29078       25116      0.53870E-02
VA6522       29077       29078 AC   0.00000E+00
LA6522       24978       29077      0.12767E-08
RA6523       29080       25119      0.53870E-02
VA6523       29079       29080 AC   0.00000E+00
LA6523       24981       29079      0.12767E-08
RA6524       29082       25122      0.53870E-02
VA6524       29081       29082 AC   0.00000E+00
LA6524       24984       29081      0.12767E-08
RA6525       29084       25125      0.53870E-02
VA6525       29083       29084 AC   0.00000E+00
LA6525       24987       29083      0.12767E-08
RA6526       29086       25128      0.53870E-02
VA6526       29085       29086 AC   0.00000E+00
LA6526       24990       29085      0.12767E-08
RA6527       29088       25131      0.53870E-02
VA6527       29087       29088 AC   0.00000E+00
LA6527       24993       29087      0.12767E-08
RA6528       29090       25134      0.53870E-02
VA6528       29089       29090 AC   0.00000E+00
LA6528       24996       29089      0.12767E-08
RA6529       29092       25137      0.53870E-02
VA6529       29091       29092 AC   0.00000E+00
LA6529       24999       29091      0.12767E-08
RA6530       29094       25140      0.53870E-02
VA6530       29093       29094 AC   0.00000E+00
LA6530       25002       29093      0.12767E-08
RA6531       29096       25143      0.53870E-02
VA6531       29095       29096 AC   0.00000E+00
LA6531       25005       29095      0.12767E-08
RA6532       29098       25146      0.53870E-02
VA6532       29097       29098 AC   0.00000E+00
LA6532       25008       29097      0.12767E-08
RA6533       29100       25149      0.53870E-02
VA6533       29099       29100 AC   0.00000E+00
LA6533       25011       29099      0.12767E-08
RA6534       29102       25152      0.53870E-02
VA6534       29101       29102 AC   0.00000E+00
LA6534       25014       29101      0.12767E-08
RA6535       29104       25155      0.53870E-02
VA6535       29103       29104 AC   0.00000E+00
LA6535       25017       29103      0.12767E-08
RA6536       29106       25158      0.53870E-02
VA6536       29105       29106 AC   0.00000E+00
LA6536       25020       29105      0.12767E-08
RA6537       29108       25161      0.53870E-02
VA6537       29107       29108 AC   0.00000E+00
LA6537       25023       29107      0.12767E-08
RA6538       29110       25164      0.53870E-02
VA6538       29109       29110 AC   0.00000E+00
LA6538       25026       29109      0.12767E-08
RA6539       29112       25167      0.53870E-02
VA6539       29111       29112 AC   0.00000E+00
LA6539       25029       29111      0.12767E-08
RA6540       29114       25170      0.53870E-02
VA6540       29113       29114 AC   0.00000E+00
LA6540       25032       29113      0.12767E-08
RA6541       29116       25173      0.53870E-02
VA6541       29115       29116 AC   0.00000E+00
LA6541       25035       29115      0.12767E-08
RA6542       29118       25176      0.53870E-02
VA6542       29117       29118 AC   0.00000E+00
LA6542       25038       29117      0.12767E-08
RA6543       29120       25179      0.53870E-02
VA6543       29119       29120 AC   0.00000E+00
LA6543       25041       29119      0.12767E-08
RA6544       29122       25182      0.53870E-02
VA6544       29121       29122 AC   0.00000E+00
LA6544       25044       29121      0.17730E-09
RA6545       29124       25185      0.53870E-02
VA6545       29123       29124 AC   0.00000E+00
LA6545       25047       29123      0.12767E-08
RA6546       29126       25188      0.53870E-02
VA6546       29125       29126 AC   0.00000E+00
LA6546       25050       29125      0.12767E-08
RA6547       29128       25191      0.53870E-02
VA6547       29127       29128 AC   0.00000E+00
LA6547       25053       29127      0.12767E-08
RA6548       29130       25194      0.53870E-02
VA6548       29129       29130 AC   0.00000E+00
LA6548       25056       29129      0.12767E-08
RA6549       29132       25197      0.53870E-02
VA6549       29131       29132 AC   0.00000E+00
LA6549       25059       29131      0.12767E-08
RA6550       29134       25200      0.53870E-02
VA6550       29133       29134 AC   0.00000E+00
LA6550       25062       29133      0.12767E-08
RA6551       29136       25203      0.53870E-02
VA6551       29135       29136 AC   0.00000E+00
LA6551       25065       29135      0.12767E-08
RA6552       29138       25206      0.53870E-02
VA6552       29137       29138 AC   0.00000E+00
LA6552       25068       29137      0.12767E-08
RA6553       29140       25209      0.53870E-02
VA6553       29139       29140 AC   0.00000E+00
LA6553       25071       29139      0.12767E-08
RA6554       29142       25212      0.53870E-02
VA6554       29141       29142 AC   0.00000E+00
LA6554       25074       29141      0.12767E-08
RA6555       29144       25215      0.53870E-02
VA6555       29143       29144 AC   0.00000E+00
LA6555       25077       29143      0.12767E-08
RA6556       29146       25218      0.53870E-02
VA6556       29145       29146 AC   0.00000E+00
LA6556       25080       29145      0.12767E-08
RA6557       29148       25221      0.53870E-02
VA6557       29147       29148 AC   0.00000E+00
LA6557       25083       29147      0.12767E-08
RA6558       29150       25224      0.53870E-02
VA6558       29149       29150 AC   0.00000E+00
LA6558       25086       29149      0.12767E-08
RA6559       29152       25227      0.53870E-02
VA6559       29151       29152 AC   0.00000E+00
LA6559       25089       29151      0.12767E-08
RA6560       29154       25230      0.53870E-02
VA6560       29153       29154 AC   0.00000E+00
LA6560       25092       29153      0.12767E-08
RA6561       29156       25233      0.53870E-02
VA6561       29155       29156 AC   0.00000E+00
LA6561       25095       29155      0.12767E-08
RA6562       29158       25236      0.53870E-02
VA6562       29157       29158 AC   0.00000E+00
LA6562       25098       29157      0.12767E-08
RA6563       29160       25239      0.53870E-02
VA6563       29159       29160 AC   0.00000E+00
LA6563       25101       29159      0.12767E-08
RA6564       29162       25242      0.53870E-02
VA6564       29161       29162 AC   0.00000E+00
LA6564       25104       29161      0.12767E-08
RA6565       29164       25245      0.53870E-02
VA6565       29163       29164 AC   0.00000E+00
LA6565       25107       29163      0.12767E-08
RA6566       29166       25248      0.53870E-02
VA6566       29165       29166 AC   0.00000E+00
LA6566       25110       29165      0.12767E-08
RA6567       29168       25251      0.53870E-02
VA6567       29167       29168 AC   0.00000E+00
LA6567       25113       29167      0.12767E-08
RA6568       29170       25254      0.53870E-02
VA6568       29169       29170 AC   0.00000E+00
LA6568       25116       29169      0.12767E-08
RA6569       29172       25257      0.53870E-02
VA6569       29171       29172 AC   0.00000E+00
LA6569       25119       29171      0.12767E-08
RA6570       29174       25260      0.53870E-02
VA6570       29173       29174 AC   0.00000E+00
LA6570       25122       29173      0.12767E-08
RA6571       29176       25263      0.53870E-02
VA6571       29175       29176 AC   0.00000E+00
LA6571       25125       29175      0.12767E-08
RA6572       29178       25266      0.53870E-02
VA6572       29177       29178 AC   0.00000E+00
LA6572       25128       29177      0.12767E-08
RA6573       29180       25269      0.53870E-02
VA6573       29179       29180 AC   0.00000E+00
LA6573       25131       29179      0.12767E-08
RA6574       29182       25272      0.53870E-02
VA6574       29181       29182 AC   0.00000E+00
LA6574       25134       29181      0.12767E-08
RA6575       29184       25275      0.53870E-02
VA6575       29183       29184 AC   0.00000E+00
LA6575       25137       29183      0.12767E-08
RA6576       29186       25278      0.53870E-02
VA6576       29185       29186 AC   0.00000E+00
LA6576       25140       29185      0.12767E-08
RA6577       29188       25281      0.53870E-02
VA6577       29187       29188 AC   0.00000E+00
LA6577       25143       29187      0.12767E-08
RA6578       29190       25284      0.53870E-02
VA6578       29189       29190 AC   0.00000E+00
LA6578       25146       29189      0.12767E-08
RA6579       29192       25287      0.53870E-02
VA6579       29191       29192 AC   0.00000E+00
LA6579       25149       29191      0.12767E-08
RA6580       29194       25290      0.53870E-02
VA6580       29193       29194 AC   0.00000E+00
LA6580       25152       29193      0.12767E-08
RA6581       29196       25293      0.53870E-02
VA6581       29195       29196 AC   0.00000E+00
LA6581       25155       29195      0.12767E-08
RA6582       29198       25296      0.53870E-02
VA6582       29197       29198 AC   0.00000E+00
LA6582       25158       29197      0.12767E-08
RA6583       29200       25299      0.53870E-02
VA6583       29199       29200 AC   0.00000E+00
LA6583       25161       29199      0.12767E-08
RA6584       29202       25302      0.53870E-02
VA6584       29201       29202 AC   0.00000E+00
LA6584       25164       29201      0.12767E-08
RA6585       29204       25305      0.53870E-02
VA6585       29203       29204 AC   0.00000E+00
LA6585       25167       29203      0.12767E-08
RA6586       29206       25308      0.53870E-02
VA6586       29205       29206 AC   0.00000E+00
LA6586       25170       29205      0.12767E-08
RA6587       29208       25311      0.53870E-02
VA6587       29207       29208 AC   0.00000E+00
LA6587       25173       29207      0.12767E-08
RA6588       29210       25314      0.53870E-02
VA6588       29209       29210 AC   0.00000E+00
LA6588       25176       29209      0.12767E-08
RA6589       29212       25317      0.53870E-02
VA6589       29211       29212 AC   0.00000E+00
LA6589       25179       29211      0.12767E-08
RA6590       29214       25320      0.53870E-02
VA6590       29213       29214 AC   0.00000E+00
LA6590       25182       29213      0.17730E-09
RA6591       29216       25323      0.53870E-02
VA6591       29215       29216 AC   0.00000E+00
LA6591       25185       29215      0.12767E-08
RA6592       29218       25326      0.53870E-02
VA6592       29217       29218 AC   0.00000E+00
LA6592       25188       29217      0.12767E-08
RA6593       29220       25329      0.53870E-02
VA6593       29219       29220 AC   0.00000E+00
LA6593       25191       29219      0.12767E-08
RA6594       29222       25332      0.53870E-02
VA6594       29221       29222 AC   0.00000E+00
LA6594       25194       29221      0.12767E-08
RA6595       29224       25335      0.53870E-02
VA6595       29223       29224 AC   0.00000E+00
LA6595       25197       29223      0.12767E-08
RA6596       29226       25338      0.53870E-02
VA6596       29225       29226 AC   0.00000E+00
LA6596       25200       29225      0.12767E-08
RA6597       29228       25341      0.53870E-02
VA6597       29227       29228 AC   0.00000E+00
LA6597       25203       29227      0.12767E-08
RA6598       29230       25344      0.53870E-02
VA6598       29229       29230 AC   0.00000E+00
LA6598       25206       29229      0.12767E-08
RA6599       29232       25347      0.53870E-02
VA6599       29231       29232 AC   0.00000E+00
LA6599       25209       29231      0.12767E-08
RA6600       29234       25350      0.53870E-02
VA6600       29233       29234 AC   0.00000E+00
LA6600       25212       29233      0.12767E-08
RA6601       29236       25353      0.53870E-02
VA6601       29235       29236 AC   0.00000E+00
LA6601       25215       29235      0.12767E-08
RA6602       29238       25356      0.53870E-02
VA6602       29237       29238 AC   0.00000E+00
LA6602       25218       29237      0.12767E-08
RA6603       29240       25359      0.53870E-02
VA6603       29239       29240 AC   0.00000E+00
LA6603       25221       29239      0.12767E-08
RA6604       29242       25362      0.53870E-02
VA6604       29241       29242 AC   0.00000E+00
LA6604       25224       29241      0.12767E-08
RA6605       29244       25365      0.53870E-02
VA6605       29243       29244 AC   0.00000E+00
LA6605       25227       29243      0.12767E-08
RA6606       29246       25368      0.53870E-02
VA6606       29245       29246 AC   0.00000E+00
LA6606       25230       29245      0.12767E-08
RA6607       29248       25371      0.53870E-02
VA6607       29247       29248 AC   0.00000E+00
LA6607       25233       29247      0.12767E-08
RA6608       29250       25374      0.53870E-02
VA6608       29249       29250 AC   0.00000E+00
LA6608       25236       29249      0.12767E-08
RA6609       29252       25377      0.53870E-02
VA6609       29251       29252 AC   0.00000E+00
LA6609       25239       29251      0.12767E-08
RA6610       29254       25380      0.53870E-02
VA6610       29253       29254 AC   0.00000E+00
LA6610       25242       29253      0.12767E-08
RA6611       29256       25383      0.53870E-02
VA6611       29255       29256 AC   0.00000E+00
LA6611       25245       29255      0.12767E-08
RA6612       29258       25386      0.53870E-02
VA6612       29257       29258 AC   0.00000E+00
LA6612       25248       29257      0.12767E-08
RA6613       29260       25389      0.53870E-02
VA6613       29259       29260 AC   0.00000E+00
LA6613       25251       29259      0.12767E-08
RA6614       29262       25392      0.53870E-02
VA6614       29261       29262 AC   0.00000E+00
LA6614       25254       29261      0.12767E-08
RA6615       29264       25395      0.53870E-02
VA6615       29263       29264 AC   0.00000E+00
LA6615       25257       29263      0.12767E-08
RA6616       29266       25398      0.53870E-02
VA6616       29265       29266 AC   0.00000E+00
LA6616       25260       29265      0.12767E-08
RA6617       29268       25401      0.53870E-02
VA6617       29267       29268 AC   0.00000E+00
LA6617       25263       29267      0.12767E-08
RA6618       29270       25404      0.53870E-02
VA6618       29269       29270 AC   0.00000E+00
LA6618       25266       29269      0.12767E-08
RA6619       29272       25407      0.53870E-02
VA6619       29271       29272 AC   0.00000E+00
LA6619       25269       29271      0.12767E-08
RA6620       29274       25410      0.53870E-02
VA6620       29273       29274 AC   0.00000E+00
LA6620       25272       29273      0.12767E-08
RA6621       29276       25413      0.53870E-02
VA6621       29275       29276 AC   0.00000E+00
LA6621       25275       29275      0.12767E-08
RA6622       29278       25416      0.53870E-02
VA6622       29277       29278 AC   0.00000E+00
LA6622       25278       29277      0.12767E-08
RA6623       29280       25419      0.53870E-02
VA6623       29279       29280 AC   0.00000E+00
LA6623       25281       29279      0.12767E-08
RA6624       29282       25422      0.53870E-02
VA6624       29281       29282 AC   0.00000E+00
LA6624       25284       29281      0.12767E-08
RA6625       29284       25425      0.53870E-02
VA6625       29283       29284 AC   0.00000E+00
LA6625       25287       29283      0.12767E-08
RA6626       29286       25428      0.53870E-02
VA6626       29285       29286 AC   0.00000E+00
LA6626       25290       29285      0.12767E-08
RA6627       29288       25431      0.53870E-02
VA6627       29287       29288 AC   0.00000E+00
LA6627       25293       29287      0.12767E-08
RA6628       29290       25434      0.53870E-02
VA6628       29289       29290 AC   0.00000E+00
LA6628       25296       29289      0.12767E-08
RA6629       29292       25437      0.53870E-02
VA6629       29291       29292 AC   0.00000E+00
LA6629       25299       29291      0.12767E-08
RA6630       29294       25440      0.53870E-02
VA6630       29293       29294 AC   0.00000E+00
LA6630       25302       29293      0.12767E-08
RA6631       29296       25443      0.53870E-02
VA6631       29295       29296 AC   0.00000E+00
LA6631       25305       29295      0.12767E-08
RA6632       29298       25446      0.53870E-02
VA6632       29297       29298 AC   0.00000E+00
LA6632       25308       29297      0.12767E-08
RA6633       29300       25449      0.53870E-02
VA6633       29299       29300 AC   0.00000E+00
LA6633       25311       29299      0.12767E-08
RA6634       29302       25452      0.53870E-02
VA6634       29301       29302 AC   0.00000E+00
LA6634       25314       29301      0.12767E-08
RA6635       29304       25455      0.53870E-02
VA6635       29303       29304 AC   0.00000E+00
LA6635       25317       29303      0.12767E-08
RA6636       29306       25458      0.53870E-02
VA6636       29305       29306 AC   0.00000E+00
LA6636       25320       29305      0.17730E-09
RA6637       29308       25461      0.53870E-02
VA6637       29307       29308 AC   0.00000E+00
LA6637       25323       29307      0.12767E-08
RA6638       29310       25464      0.53870E-02
VA6638       29309       29310 AC   0.00000E+00
LA6638       25326       29309      0.12767E-08
RA6639       29312       25467      0.53870E-02
VA6639       29311       29312 AC   0.00000E+00
LA6639       25329       29311      0.12767E-08
RA6640       29314       25470      0.53870E-02
VA6640       29313       29314 AC   0.00000E+00
LA6640       25332       29313      0.12767E-08
RA6641       29316       25473      0.53870E-02
VA6641       29315       29316 AC   0.00000E+00
LA6641       25335       29315      0.12767E-08
RA6642       29318       25476      0.53870E-02
VA6642       29317       29318 AC   0.00000E+00
LA6642       25338       29317      0.12767E-08
RA6643       29320       25479      0.53870E-02
VA6643       29319       29320 AC   0.00000E+00
LA6643       25341       29319      0.12767E-08
RA6644       29322       25482      0.53870E-02
VA6644       29321       29322 AC   0.00000E+00
LA6644       25344       29321      0.12767E-08
RA6645       29324       25485      0.53870E-02
VA6645       29323       29324 AC   0.00000E+00
LA6645       25347       29323      0.12767E-08
RA6646       29326       25488      0.53870E-02
VA6646       29325       29326 AC   0.00000E+00
LA6646       25350       29325      0.12767E-08
RA6647       29328       25491      0.53870E-02
VA6647       29327       29328 AC   0.00000E+00
LA6647       25353       29327      0.12767E-08
RA6648       29330       25494      0.53870E-02
VA6648       29329       29330 AC   0.00000E+00
LA6648       25356       29329      0.12767E-08
RA6649       29332       25497      0.53870E-02
VA6649       29331       29332 AC   0.00000E+00
LA6649       25359       29331      0.12767E-08
RA6650       29334       25500      0.53870E-02
VA6650       29333       29334 AC   0.00000E+00
LA6650       25362       29333      0.12767E-08
RA6651       29336       25503      0.53870E-02
VA6651       29335       29336 AC   0.00000E+00
LA6651       25365       29335      0.12767E-08
RA6652       29338       25506      0.53870E-02
VA6652       29337       29338 AC   0.00000E+00
LA6652       25368       29337      0.12767E-08
RA6653       29340       25509      0.53870E-02
VA6653       29339       29340 AC   0.00000E+00
LA6653       25371       29339      0.12767E-08
RA6654       29342       25512      0.53870E-02
VA6654       29341       29342 AC   0.00000E+00
LA6654       25374       29341      0.12767E-08
RA6655       29344       25515      0.53870E-02
VA6655       29343       29344 AC   0.00000E+00
LA6655       25377       29343      0.12767E-08
RA6656       29346       25518      0.53870E-02
VA6656       29345       29346 AC   0.00000E+00
LA6656       25380       29345      0.12767E-08
RA6657       29348       25521      0.53870E-02
VA6657       29347       29348 AC   0.00000E+00
LA6657       25383       29347      0.12767E-08
RA6658       29350       25524      0.53870E-02
VA6658       29349       29350 AC   0.00000E+00
LA6658       25386       29349      0.12767E-08
RA6659       29352       25527      0.53870E-02
VA6659       29351       29352 AC   0.00000E+00
LA6659       25389       29351      0.12767E-08
RA6660       29354       25530      0.53870E-02
VA6660       29353       29354 AC   0.00000E+00
LA6660       25392       29353      0.12767E-08
RA6661       29356       25533      0.53870E-02
VA6661       29355       29356 AC   0.00000E+00
LA6661       25395       29355      0.12767E-08
RA6662       29358       25536      0.53870E-02
VA6662       29357       29358 AC   0.00000E+00
LA6662       25398       29357      0.12767E-08
RA6663       29360       25539      0.53870E-02
VA6663       29359       29360 AC   0.00000E+00
LA6663       25401       29359      0.12767E-08
RA6664       29362       25542      0.53870E-02
VA6664       29361       29362 AC   0.00000E+00
LA6664       25404       29361      0.12767E-08
RA6665       29364       25545      0.53870E-02
VA6665       29363       29364 AC   0.00000E+00
LA6665       25407       29363      0.12767E-08
RA6666       29366       25548      0.53870E-02
VA6666       29365       29366 AC   0.00000E+00
LA6666       25410       29365      0.12767E-08
RA6667       29368       25551      0.53870E-02
VA6667       29367       29368 AC   0.00000E+00
LA6667       25413       29367      0.12767E-08
RA6668       29370       25554      0.53870E-02
VA6668       29369       29370 AC   0.00000E+00
LA6668       25416       29369      0.12767E-08
RA6669       29372       25557      0.53870E-02
VA6669       29371       29372 AC   0.00000E+00
LA6669       25419       29371      0.12767E-08
RA6670       29374       25560      0.53870E-02
VA6670       29373       29374 AC   0.00000E+00
LA6670       25422       29373      0.12767E-08
RA6671       29376       25563      0.53870E-02
VA6671       29375       29376 AC   0.00000E+00
LA6671       25425       29375      0.12767E-08
RA6672       29378       25566      0.53870E-02
VA6672       29377       29378 AC   0.00000E+00
LA6672       25428       29377      0.12767E-08
RA6673       29380       25569      0.53870E-02
VA6673       29379       29380 AC   0.00000E+00
LA6673       25431       29379      0.12767E-08
RA6674       29382       25572      0.53870E-02
VA6674       29381       29382 AC   0.00000E+00
LA6674       25434       29381      0.12767E-08
RA6675       29384       25575      0.53870E-02
VA6675       29383       29384 AC   0.00000E+00
LA6675       25437       29383      0.12767E-08
RA6676       29386       25578      0.53870E-02
VA6676       29385       29386 AC   0.00000E+00
LA6676       25440       29385      0.12767E-08
RA6677       29388       25581      0.53870E-02
VA6677       29387       29388 AC   0.00000E+00
LA6677       25443       29387      0.12767E-08
RA6678       29390       25584      0.53870E-02
VA6678       29389       29390 AC   0.00000E+00
LA6678       25446       29389      0.12767E-08
RA6679       29392       25587      0.53870E-02
VA6679       29391       29392 AC   0.00000E+00
LA6679       25449       29391      0.12767E-08
RA6680       29394       25590      0.53870E-02
VA6680       29393       29394 AC   0.00000E+00
LA6680       25452       29393      0.12767E-08
RA6681       29396       25593      0.53870E-02
VA6681       29395       29396 AC   0.00000E+00
LA6681       25455       29395      0.12767E-08
RA6682       29398       25596      0.53870E-02
VA6682       29397       29398 AC   0.00000E+00
LA6682       25458       29397      0.17730E-09
RA6683       29400       25599      0.53870E-02
VA6683       29399       29400 AC   0.00000E+00
LA6683       25461       29399      0.12767E-08
RA6684       29402       25602      0.53870E-02
VA6684       29401       29402 AC   0.00000E+00
LA6684       25464       29401      0.12767E-08
RA6685       29404       25605      0.53870E-02
VA6685       29403       29404 AC   0.00000E+00
LA6685       25467       29403      0.12767E-08
RA6686       29406       25608      0.53870E-02
VA6686       29405       29406 AC   0.00000E+00
LA6686       25470       29405      0.12767E-08
RA6687       29408       25611      0.53870E-02
VA6687       29407       29408 AC   0.00000E+00
LA6687       25473       29407      0.12767E-08
RA6688       29410       25614      0.53870E-02
VA6688       29409       29410 AC   0.00000E+00
LA6688       25476       29409      0.12767E-08
RA6689       29412       25617      0.53870E-02
VA6689       29411       29412 AC   0.00000E+00
LA6689       25479       29411      0.12767E-08
RA6690       29414       25620      0.53870E-02
VA6690       29413       29414 AC   0.00000E+00
LA6690       25482       29413      0.12767E-08
RA6691       29416       25623      0.53870E-02
VA6691       29415       29416 AC   0.00000E+00
LA6691       25485       29415      0.12767E-08
RA6692       29418       25626      0.53870E-02
VA6692       29417       29418 AC   0.00000E+00
LA6692       25488       29417      0.12767E-08
RA6693       29420       25629      0.53870E-02
VA6693       29419       29420 AC   0.00000E+00
LA6693       25491       29419      0.12767E-08
RA6694       29422       25632      0.53870E-02
VA6694       29421       29422 AC   0.00000E+00
LA6694       25494       29421      0.12767E-08
RA6695       29424       25635      0.53870E-02
VA6695       29423       29424 AC   0.00000E+00
LA6695       25497       29423      0.12767E-08
RA6696       29426       25638      0.53870E-02
VA6696       29425       29426 AC   0.00000E+00
LA6696       25500       29425      0.12767E-08
RA6697       29428       25641      0.53870E-02
VA6697       29427       29428 AC   0.00000E+00
LA6697       25503       29427      0.12767E-08
RA6698       29430       25644      0.53870E-02
VA6698       29429       29430 AC   0.00000E+00
LA6698       25506       29429      0.12767E-08
RA6699       29432       25647      0.53870E-02
VA6699       29431       29432 AC   0.00000E+00
LA6699       25509       29431      0.12767E-08
RA6700       29434       25650      0.53870E-02
VA6700       29433       29434 AC   0.00000E+00
LA6700       25512       29433      0.12767E-08
RA6701       29436       25653      0.53870E-02
VA6701       29435       29436 AC   0.00000E+00
LA6701       25515       29435      0.12767E-08
RA6702       29438       25656      0.53870E-02
VA6702       29437       29438 AC   0.00000E+00
LA6702       25518       29437      0.12767E-08
RA6703       29440       25659      0.53870E-02
VA6703       29439       29440 AC   0.00000E+00
LA6703       25521       29439      0.12767E-08
RA6704       29442       25662      0.53870E-02
VA6704       29441       29442 AC   0.00000E+00
LA6704       25524       29441      0.12767E-08
RA6705       29444       25665      0.53870E-02
VA6705       29443       29444 AC   0.00000E+00
LA6705       25527       29443      0.12767E-08
RA6706       29446       25668      0.53870E-02
VA6706       29445       29446 AC   0.00000E+00
LA6706       25530       29445      0.12767E-08
RA6707       29448       25671      0.53870E-02
VA6707       29447       29448 AC   0.00000E+00
LA6707       25533       29447      0.12767E-08
RA6708       29450       25674      0.53870E-02
VA6708       29449       29450 AC   0.00000E+00
LA6708       25536       29449      0.12767E-08
RA6709       29452       25677      0.53870E-02
VA6709       29451       29452 AC   0.00000E+00
LA6709       25539       29451      0.12767E-08
RA6710       29454       25680      0.53870E-02
VA6710       29453       29454 AC   0.00000E+00
LA6710       25542       29453      0.12767E-08
RA6711       29456       25683      0.53870E-02
VA6711       29455       29456 AC   0.00000E+00
LA6711       25545       29455      0.12767E-08
RA6712       29458       25686      0.53870E-02
VA6712       29457       29458 AC   0.00000E+00
LA6712       25548       29457      0.12767E-08
RA6713       29460       25689      0.53870E-02
VA6713       29459       29460 AC   0.00000E+00
LA6713       25551       29459      0.12767E-08
RA6714       29462       25692      0.53870E-02
VA6714       29461       29462 AC   0.00000E+00
LA6714       25554       29461      0.12767E-08
RA6715       29464       25695      0.53870E-02
VA6715       29463       29464 AC   0.00000E+00
LA6715       25557       29463      0.12767E-08
RA6716       29466       25698      0.53870E-02
VA6716       29465       29466 AC   0.00000E+00
LA6716       25560       29465      0.12767E-08
RA6717       29468       25701      0.53870E-02
VA6717       29467       29468 AC   0.00000E+00
LA6717       25563       29467      0.12767E-08
RA6718       29470       25704      0.53870E-02
VA6718       29469       29470 AC   0.00000E+00
LA6718       25566       29469      0.12767E-08
RA6719       29472       25707      0.53870E-02
VA6719       29471       29472 AC   0.00000E+00
LA6719       25569       29471      0.12767E-08
RA6720       29474       25710      0.53870E-02
VA6720       29473       29474 AC   0.00000E+00
LA6720       25572       29473      0.12767E-08
RA6721       29476       25713      0.53870E-02
VA6721       29475       29476 AC   0.00000E+00
LA6721       25575       29475      0.12767E-08
RA6722       29478       25716      0.53870E-02
VA6722       29477       29478 AC   0.00000E+00
LA6722       25578       29477      0.12767E-08
RA6723       29480       25719      0.53870E-02
VA6723       29479       29480 AC   0.00000E+00
LA6723       25581       29479      0.12767E-08
RA6724       29482       25722      0.53870E-02
VA6724       29481       29482 AC   0.00000E+00
LA6724       25584       29481      0.12767E-08
RA6725       29484       25725      0.53870E-02
VA6725       29483       29484 AC   0.00000E+00
LA6725       25587       29483      0.12767E-08
RA6726       29486       25728      0.53870E-02
VA6726       29485       29486 AC   0.00000E+00
LA6726       25590       29485      0.12767E-08
RA6727       29488       25731      0.53870E-02
VA6727       29487       29488 AC   0.00000E+00
LA6727       25593       29487      0.12767E-08
RA6728       29490       25734      0.53870E-02
VA6728       29489       29490 AC   0.00000E+00
LA6728       25596       29489      0.17730E-09
* WIREBOND ARRAY ELEMENTS:
LWBa6729       22886       22899      0.73997E-09
*
*
*
I0 0 23568 SIN (0 0.0333333 1e+09 0 0 )
I1 0 23518 SIN (0 0.0333333 1e+09 0 0 )
I2 0 23468 SIN (0 0.0333333 1e+09 0 0 )
I3 0 23418 SIN (0 0.0333333 1e+09 0 0 )
I4 0 23368 SIN (0 0.0333333 1e+09 0 0 )
I5 0 23318 SIN (0 0.0333333 1e+09 0 0 )
I6 0 23268 SIN (0 0.0333333 1e+09 0 0 )
I7 0 23218 SIN (0 0.0333333 1e+09 0 0 )
I8 0 23168 SIN (0 0.0333333 1e+09 0 0 )
I9 0 23118 SIN (0 0.0333333 1e+09 0 0 )
I10 0 23068 SIN (0 0.0333333 1e+09 0 0 )
I11 0 23018 SIN (0 0.0333333 1e+09 0 0 )
I12 0 22968 SIN (0 0.0333333 1e+09 0 0 )
I13 0 22918 SIN (0 0.0333333 1e+09 0 0 )
I14 0 22868 SIN (0 0.0333333 1e+09 0 0 )
I15 0 22818 SIN (0 0.0333333 1e+09 0 0 )
I16 0 22768 SIN (0 0.0333333 1e+09 0 0 )
I17 0 22718 SIN (0 0.0333333 1e+09 0 0 )
I18 0 22668 SIN (0 0.0333333 1e+09 0 0 )
I19 0 22618 SIN (0 0.0333333 1e+09 0 0 )
I20 0 22568 SIN (0 0.0333333 1e+09 0 0 )
I21 0 22518 SIN (0 0.0333333 1e+09 0 0 )
I22 0 22468 SIN (0 0.0333333 1e+09 0 0 )
I23 0 22418 SIN (0 0.0333333 1e+09 0 0 )
I24 0 22368 SIN (0 0.0333333 1e+09 0 0 )
I25 0 22318 SIN (0 0.0333333 1e+09 0 0 )
I26 0 22268 SIN (0 0.0333333 1e+09 0 0 )
I27 0 22218 SIN (0 0.0333333 1e+09 0 0 )
I28 0 22168 SIN (0 0.0333333 1e+09 0 0 )
I29 0 22118 SIN (0 0.0333333 1e+09 0 0 )

.print tran V(22118)
.print tran V(22121)
.print tran V(22124)
.print tran I(VA5530)
.print tran I(VA2420)
.print tran I(VA5531)
.print tran I(VA2418)
.options acct
.TRAN 1e-09 2e-08
.end
*
*.END
*
